# IAR project cslib.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: EFM32ZG222F32 SiliconLaboratories EFM32ZG222F32
  ICCARM.CCDefines: EFM32ZG222F32; DEBUG_EFM; RETARGET_VCOM
  ICCARM.CCIncludePath2: ..\..\..\..\..\platform\CMSIS\Include; ..\..\..\..\..\platform\Device\SiliconLabs\EFM32ZG\Include; ..\..\..\..\..\platform\emlib\inc; ..\..\..\..\..\hardware\kit\common\bsp; ..\..\..\..\..\hardware\kit\common\drivers; ..\..\..\..\..\hardware\kit\EFM32ZG_STK3200\config; ..\..\..\..\..\platform\middleware\cslib\inc; ..\..\..\..\..\platform\middleware\cslib\src\app; ..\..\..\..\..\platform\middleware\cslib\src\device_ACMP; ..\..\..\..\..\platform\middleware\cslib\src\serial; ..\..\..\..\..\platform\middleware\cslib\src\config_ACMP
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.ADefines: EFM32ZG222F32; DEBUG_EFM; RETARGET_VCOM
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: cslib.bin
  ILINK.IlinkOutputFile: cslib.out
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\platform\middleware\cslib\lib\libCSLIB_M0_iar.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32ZG222F32; DEBUG_EFM; RETARGET_VCOM
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFM32ZG/Source/IAR/: startup_efm32zg.s
    ../../../../../platform/Device/SiliconLabs/EFM32ZG/Source/: system_efm32zg.c
  group bsp
    ../../../../../hardware/kit/common/bsp/: bsp_bcc.c bsp_stk.c bsp_stk_leds.c bsp_trace.c
  group emlib
    ../../../../../platform/emlib/src/: em_acmp.c em_assert.c em_cmu.c em_ebi.c em_emu.c em_gpio.c em_core.c em_rtc.c em_system.c em_usart.c em_leuart.c
  group app
    ../../../../../platform/middleware/cslib/src/app/: cslib_config.c device_init.c
  group device_ACMP
    ../../../../../platform/middleware/cslib/src/device_ACMP/: hardware_config.c hardware_routines.c low_power_config.c
  group serial
    ../../../../../platform/middleware/cslib/src/serial/: comm_routines.c profiler_interface.c sensor_descriptors.c
    ../../../../../hardware/kit/common/drivers/: retargetserial.c retargetio.c
  group Source
    ../: main.c
