# Keil uVision project preamp.uvprojx, settings and files
target preamp (ARM-ADS)
  device: EFM32WG990F256 Silicon Labs
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(48000000) CPUTYPE("Cortex-M4") FPU2
  output: preamp
  AfterMake: fromelf.exe --bin --output obj\preamp.bin obj\preamp.axf
  c flags: Optim=4 oTime=1
  c define: EFM32WG990F256 DEBUG_EFM ARM_MATH_CM4 __FPU_PRESENT=1
  c misc: --c99 --diag_suppress=47
  c include: ..\;..\..\..\..\..\platform\CMSIS\Include;..\..\..\..\..\platform\Device\SiliconLabs\EFM32WG\Include;..\..\..\..\..\platform\emlib\inc;..\..\..\..\..\hardware\kit\EFM32WG_DK3850\config;..\..\..\..\..\hardware\kit\common\drivers;..\..\..\..\..\hardware\kit\common\bsp;..\..\..\..\..\platform\middleware\glib;..\..\..\..\..\util\third_party\emwin\inc;..\..\..\..\..\hardware\kit\common\drivers\emwin\Dk3750;..\..\..\..\..\hardware\kit\EFM32WG_DK3850\config
  asm define: EFM32WG990F256 DEBUG_EFM ARM_MATH_CM4 __FPU_PRESENT=1
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFM32WG/Source/ARM/: startup_efm32wg.s
    ../../../../../platform/Device/SiliconLabs/EFM32WG/Source/: system_efm32wg.c
  group bsp
    ../../../../../hardware/kit/common/bsp/: bsp_dk_3201.c bsp_dk_leds.c bsp_trace.c
  group Drivers
    ../../../../../hardware/kit/common/drivers/: dmactrl.c
  group DSP
    ../../../../../platform/CMSIS/DSP_Lib/Source/FilteringFunctions/: arm_biquad_cascade_df1_init_f32.c arm_biquad_cascade_df1_f32.c
  group emlib
    ../../../../../platform/emlib/src/: em_adc.c em_assert.c em_cmu.c em_dma.c em_ebi.c em_emu.c em_core.c em_gpio.c em_prs.c em_system.c em_timer.c em_usart.c
  group Source
    ../: preamp.c preamp.h plot.c plot.h logo.c logo.h GUI_X.c LCDConf_mm.c
  group emwin
    ../../../../../hardware/kit/common/drivers/emwin/Dk3750/: GUIConf.c ssd2119.c
  group Libraries
    ../../../../../util/third_party/emwin/lib/: emwin_ARM_CM4F.lib
