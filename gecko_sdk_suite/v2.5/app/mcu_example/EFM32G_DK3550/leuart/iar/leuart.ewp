# IAR project leuart.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: EFM32G890F128 SiliconLaboratories EFM32G890F128
  ICCARM.CCDefines: EFM32G890F128; DEBUG_EFM
  ICCARM.CCIncludePath2: ..\..\..\..\..\platform\CMSIS\Include; ..\..\..\..\..\platform\Device\SiliconLabs\EFM32G\Include; ..\..\..\..\..\platform\emlib\inc; ..\..\..\..\..\hardware\kit\common\bsp; ..\..\..\..\..\hardware\kit\common\drivers; ..\..\..\..\..\hardware\kit\EFM32G_DK3550\config
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.ADefines: EFM32G890F128; DEBUG_EFM
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: leuart.bin
  ILINK.IlinkOutputFile: leuart.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32G890F128; DEBUG_EFM
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group bsp
    ../../../../../hardware/kit/common/bsp/: bsp_dk_3201.c bsp_dk_leds.c bsp_trace.c
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFM32G/Source/IAR/: startup_efm32g.s
    ../../../../../platform/Device/SiliconLabs/EFM32G/Source/: system_efm32g.c
  group Drivers
    ../../../../../hardware/kit/common/drivers/: dmactrl.c
  group emlib
    ../../../../../platform/emlib/src/: em_assert.c em_system.c em_cmu.c em_emu.c em_gpio.c em_ebi.c em_usart.c em_leuart.c em_dma.c
  group Source
    ../: main.c
