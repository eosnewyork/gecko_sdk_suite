# IAR project usbdpdmmic.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32GG12B810F1024GM64 SiliconLaboratories EFM32GG12B810F1024GM64
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: EFM32GG12B810F1024GM64; DEBUG_EFM_USER; RETARGET_VCOM
  ICCARM.CCIncludePath2: ..; ..\..\..\..\..\platform\CMSIS\Include; ..\..\..\..\..\platform\Device\SiliconLabs\EFM32GG12B\Include; ..\..\..\..\..\platform\emlib\inc; ..\..\..\..\..\platform\emdrv\common\inc; ..\..\..\..\..\platform\emdrv\dmadrv\inc; ..\..\..\..\..\platform\middleware\usb_gecko\inc; ..\..\..\..\..\hardware\kit\common\drivers; ..\..\..\..\..\hardware\kit\common\bsp; ..\..\..\..\..\hardware\kit\SLTB009A_EFM32GG12\config
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: EFM32GG12B810F1024GM64; DEBUG_EFM_USER; RETARGET_VCOM
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: usbdpdmmic.bin
  ILINK.IlinkOutputFile: usbdpdmmic.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32GG12B810F1024GM64; DEBUG_EFM_USER; RETARGET_VCOM
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFM32GG12B/Source/IAR/: startup_efm32gg12b.s
    ../../../../../platform/Device/SiliconLabs/EFM32GG12B/Source/: system_efm32gg12b.c
  group bsp
    ../../../../../hardware/kit/common/bsp/: bsp_trace.c
  group drivers
    ../../../../../hardware/kit/common/drivers/: retargetio.c retargetserial.c
    ../../../../../platform/emdrv/dmadrv/src/: dmadrv.c
  group emlib
    ../../../../../platform/emlib/src/: em_assert.c em_cmu.c em_core.c em_emu.c em_gpio.c em_ldma.c em_pdm.c em_system.c em_timer.c em_usart.c
  group emusb
    ../../../../../platform/middleware/usb_gecko/src/: em_usbd.c em_usbdch9.c em_usbhal.c em_usbdep.c em_usbdint.c em_usbtimer.c
  group Source
    ../: main.c descriptors.c
