# Keil uVision project vcom.uvprojx, settings and files
target vcom (ARM-ADS)
  device: EFM32GG12B810F1024GM64 Silicon Labs
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0-0xFFFFF) CLOCK(48000000) CPUTYPE("Cortex-M3")
  output: vcom
  AfterMake: fromelf.exe --bin --output obj\vcom.bin obj\vcom.axf
  c flags: Optim=1 oTime=1
  c define: EFM32GG12B810F1024GM64 DEBUG_EFM RETARGET_VCOM
  c misc: --c99
  c include: ..\;..\..\..\..\..\platform\CMSIS\Include;..\..\..\..\..\platform\Device\SiliconLabs\EFM32GG12B\Include;..\..\..\..\..\platform\emlib\inc;..\..\..\..\..\hardware\kit\common\bsp;..\..\..\..\..\hardware\kit\common\drivers;..\..\..\..\..\hardware\kit\SLTB009A_EFM32GG12\config
  asm define: EFM32GG12B810F1024GM64 DEBUG_EFM RETARGET_VCOM
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Drivers
    ../../../../../hardware/kit/common/drivers/: retargetio.c retargetserial.c
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFM32GG12B/Source/ARM/: startup_efm32gg12b.s
    ../../../../../platform/Device/SiliconLabs/EFM32GG12B/Source/: system_efm32gg12b.c
  group emlib
    ../../../../../platform/emlib/src/: em_assert.c em_system.c em_cmu.c em_core.c em_emu.c em_gpio.c em_usart.c em_leuart.c
  group Source
    ../: main.c
