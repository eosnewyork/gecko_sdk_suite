# IAR project rs232.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: EZR32LG330F256R60 SiliconLaboratories EZR32LG330F256R60
  ICCARM.CCDefines: EZR32LG330F256R60; DEBUG_EFM
  ICCARM.CCIncludePath2: ..\..\..\..\..\platform\CMSIS\Include; ..\..\..\..\..\platform\Device\SiliconLabs\EZR32LG\Include; ..\..\..\..\..\platform\emlib\inc; ..\..\..\..\..\hardware\kit\common\bsp; ..\..\..\..\..\hardware\kit\common\drivers; ..\..\..\..\..\hardware\kit\SLWSTK6200A_EZR32LG\config
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.ADefines: EZR32LG330F256R60; DEBUG_EFM
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: rs232.bin
  ILINK.IlinkOutputFile: rs232.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EZR32LG330F256R60; DEBUG_EFM
  group Drivers
    ../../../../../hardware/kit/common/drivers/: retargetio.c retargetserial.c
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EZR32LG/Source/IAR/: startup_ezr32lg.s
    ../../../../../platform/Device/SiliconLabs/EZR32LG/Source/: system_ezr32lg.c
  group emlib
    ../../../../../platform/emlib/src/: em_assert.c em_system.c em_cmu.c em_core.c em_emu.c em_gpio.c em_ebi.c em_usart.c em_leuart.c
  group Source
    ../: main.c
