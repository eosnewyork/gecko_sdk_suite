# IAR project sensor_puck.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: EFM32G210F128 SiliconLaboratories EFM32G210F128
  ICCARM.CCDefines: EFM32G210F128; EFM32_HFXO_FREQ=24000000; EMDRV_RTCDRV_USE_LFRCO
  ICCARM.CCIncludePath2: ..\..\..\..\..\platform\CMSIS\Include; ..\..\..\..\..\platform\Device\SiliconLabs\EFM32G\Include; ..\..\..\..\..\platform\emlib\inc; ..\..\..\..\..\hardware\kit\common\drivers; ..\..\..; ..\..\..\..\..\hardware\kit\SLSENSORPUCK_EFM32G\config; ..\..\..\..\..\platform\emdrv\common\inc; ..\..\..\..\..\platform\emdrv\rtcdrv\inc; ..\..\..\..\..\platform\emdrv\rtcdrv\config; ..\..\..\..\..\util\silicon_labs\sensor_si114xhrm\inc
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: sensor_puck.bin
  ILINK.IlinkOutputFile: sensor_puck.out
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\util\silicon_labs\sensor_si114xhrm\lib\libsi114xHRM_IAR_CM3.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32G210F128; EFM32_HFXO_FREQ=24000000; EMDRV_RTCDRV_USE_LFRCO
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFM32G/Source/IAR/: startup_efm32g.s
    ../../../../../platform/Device/SiliconLabs/EFM32G/Source/: system_efm32g.c
  group Drivers
    ../../../../../hardware/kit/common/drivers/: si7013.c si114x_functions.c
  group emlib
    ../../../../../platform/emlib/src/: em_adc.c em_assert.c em_cmu.c em_core.c em_dma.c em_emu.c em_gpio.c em_lcd.c em_prs.c em_system.c em_timer.c em_usart.c em_rtc.c em_i2c.c em_msc.c em_leuart.c
  group emdrv
    ../../../../../platform/emdrv/rtcdrv/src/: rtcdriver.c
  group Source
    ../: sensor_puck.c sensor_puck.h heart_rate_monitor.c heart_rate_monitor.h heart_rate_monitor_config.h ble.c ble.h ble_uart.c ble_uart.h si114x_environmental.c si114x_environmental.h trace.c trace.h si114x_sys_out_puck.c si114x_sys_out_puck.h i2cspm_int.c
