# Keil uVision project sensor_puck.uvprojx, settings and files
target sensor_puck (ARM-ADS)
  device: EFM32G210F128 Silicon Labs
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(14000000) CPUTYPE("Cortex-M3")
  output: sensor_puck
  AfterMake: fromelf.exe --bin --output obj\sensor_puck.bin obj\sensor_puck.axf
  c flags: Optim=4 oTime=1
  c define: EFM32G210F128 EFM32_HFXO_FREQ=24000000 EMDRV_RTCDRV_USE_LFRCO
  c misc: --c99
  c include: ..\;..\..\..\..\..\platform\CMSIS\Include;..\..\..\..\..\platform\Device\SiliconLabs\EFM32G\Include;..\..\..\..\..\platform\emlib\inc;..\..\..\..\..\hardware\kit\common\drivers;..\..\..;..\..\..\..\..\hardware\kit\SLSENSORPUCK_EFM32G\config;..\..\..\..\..\platform\emdrv\common\inc;..\..\..\..\..\platform\emdrv\rtcdrv\inc;..\..\..\..\..\platform\emdrv\rtcdrv\config;..\..\..\..\..\util\silicon_labs\sensor_si114xhrm\inc
  asm define: as above
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ram_code.sct
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFM32G/Source/ARM/: startup_efm32g.s
    ../../../../../platform/Device/SiliconLabs/EFM32G/Source/: system_efm32g.c
  group Drivers
    ../../../../../hardware/kit/common/drivers/: si7013.c si114x_functions.c
  group emlib
    ../../../../../platform/emlib/src/: em_adc.c em_assert.c em_cmu.c em_core.c em_dma.c em_emu.c em_gpio.c em_lcd.c em_prs.c em_system.c em_timer.c em_usart.c em_rtc.c em_i2c.c em_msc.c em_leuart.c
  group emdrv
    ../../../../../platform/emdrv/rtcdrv/src/: rtcdriver.c
  group Source
    ../: sensor_puck.c sensor_puck.h heart_rate_monitor.c heart_rate_monitor.h heart_rate_monitor_config.h ble.c ble.h ble_uart.c ble_uart.h si114x_environmental.c si114x_environmental.h trace.c trace.h si114x_sys_out_puck.c si114x_sys_out_puck.h i2cspm_int.c
  group Libraries
    ../../../../../util/silicon_labs/sensor_si114xhrm/lib/: si114xHRM_ARM_CM3.lib
