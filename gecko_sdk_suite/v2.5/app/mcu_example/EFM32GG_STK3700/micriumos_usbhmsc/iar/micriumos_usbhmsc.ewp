# IAR project micriumos_usbhmsc.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: EFM32GG990F1024 SiliconLaboratories EFM32GG990F1024
  ICCARM.CCDefines: EFM32GG990F1024; DEBUG_EFM; RETARGET_VCOM; RETARGET_UART0
  ICCARM.CCIncludePath2: ..\..\..\..\..\platform\CMSIS\Include; ..\..\..\..\..\platform\Device\SiliconLabs\EFM32GG\Include; ..\..\..\..\..\platform\emlib\inc; ..\..\..\..\..\hardware\kit\common\bsp; ..\..\..\..\..\hardware\kit\common\drivers; ..\..\..\..\..\hardware\kit\EFM32GG_STK3700\config; ..\..\..\..\..\platform\micrium_os; ..\..\..\..\..\platform\micrium_os\bsp\siliconlabs\generic\include; ..\cfg; ..; ..\..\..\..\..\util\third_party\segger\systemview\SEGGER; ..\..\..\..\..\util\third_party\segger\systemview\Config; ..\..\..\..\..\util\third_party\segger\systemview\Sample\MicriumOSKernel
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.ADefines: EFM32GG990F1024; DEBUG_EFM; RETARGET_VCOM; RETARGET_UART0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: micriumos_usbhmsc.bin
  ILINK.IlinkOutputFile: micriumos_usbhmsc.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32GG990F1024; DEBUG_EFM; RETARGET_VCOM; RETARGET_UART0
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFM32GG/Source/IAR/: startup_efm32gg.s
    ../../../../../platform/Device/SiliconLabs/EFM32GG/Source/: system_efm32gg.c
  group bsp
    ../../../../../hardware/kit/common/bsp/: bsp_bcc.c bsp_stk.c bsp_stk_leds.c bsp_trace.c
    ../../../../../platform/micrium_os/bsp/siliconlabs/generic/source/: bsp_cpu.c bsp_os.c bsp_usb_host_pbhcd.c
  group emlib
    ../../../../../platform/emlib/src/: em_assert.c em_core.c em_cmu.c em_ebi.c em_emu.c em_gpio.c em_system.c em_usart.c
  group common
    ../../../../../platform/micrium_os/common/source/auth/: auth.c
    ../../../../../platform/micrium_os/common/source/clk/: clk.c clk_cmd.c
    ../../../../../platform/micrium_os/common/source/collections/: bitmap.c map.c slist.c
    ../../../../../platform/micrium_os/common/source/common/: common.c
    ../../../../../platform/micrium_os/common/source/kal/: kal_kernel.c
    ../../../../../platform/micrium_os/common/source/lib/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../../../../../platform/micrium_os/common/source/rtos/: rtos_err_str.c
    ../../../../../platform/micrium_os/common/source/platform_mgr/: platform_mgr.c
    ../../../../../platform/micrium_os/common/source/op_lock/: op_lock.c
  group cpu
    ../../../../../platform/micrium_os/cpu/source/: cpu_core.c
    ../../../../../platform/micrium_os/ports/source/iar/: armv7m_cpu_a.asm
    ../../../../../platform/micrium_os/ports/source/generic/: armv6m_v7m_cpu_int.c
  group drivers
    ../../../../../platform/micrium_os/drivers/usb/source/host_pbhcds/: usbh_pbhcd_dwc_otg_fs.c
    ../../../../../hardware/kit/common/drivers/: retargetio.c retargetserial.c
  group kernel
    ../../../../../platform/micrium_os/kernel/source/: os_core.c os_cfg_app.c os_dbg.c os_flag.c os_mem.c os_mon.c os_msg.c os_mutex.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
    ../../../../../platform/micrium_os/ports/source/iar/: armv7m_os_cpu_a.asm armv7m_os_cpu_c.c
  group fs
    ../../../../../platform/micrium_os/fs/source/storage/: fs_storage.c fs_blk_dev.c fs_media.c
    ../../../../../platform/micrium_os/fs/source/storage/ramdisk/: fs_ramdisk.c
    ../../../../../platform/micrium_os/fs/source/storage/scsi/: fs_scsi.c
    ../../../../../platform/micrium_os/fs/source/shared/: fs_obj.c fs_utils.c
    ../../../../../platform/micrium_os/fs/source/core/: fs_core.c fs_core_buddy_alloc.c fs_core_cache.c fs_core_entry.c fs_core_file.c fs_core_list.c fs_core_vol.c fs_core_partition.c fs_core_job_sched.c fs_core_op.c fs_core_unicode.c fs_core_dir.c fs_core_working_dir.c fs_core_posix.c
    ../../../../../platform/micrium_os/fs/source/sys/fat/: fs_fat.c fs_fat_dir.c fs_fat_entry.c fs_fat_file.c fs_fat_lfn.c fs_fat_journal.c fs_fat_vol.c fs_fat_fatxx.c
    ../../../../../platform/micrium_os/fs/source/sys/: fs_sys.c
  group usb
    ../../../../../platform/micrium_os/usb/source/host/core/: usbh_core.c usbh_core_dev.c usbh_core_ep.c usbh_core_hub.c usbh_core_class.c usbh_core_config.c usbh_core_fnct.c usbh_core_if.c
    ../../../../../platform/micrium_os/usb/source/host/hcd/: usbh_pbhci.c
    ../../../../../platform/micrium_os/usb/source/host/class/: usbh_msc.c usbh_class_common.c
    ../../../../../platform/micrium_os/usb/source/: usb_ctrlr.c
  group SystemView
    ../../../../../util/third_party/segger/systemview/SEGGER/: SEGGER_RTT.c SEGGER_SYSVIEW.c
    ../../../../../util/third_party/segger/systemview/Sample/MicriumOSKernel/: SEGGER_SYSVIEW_MicriumOSKernel.c
    ../cfg/: SEGGER_SYSVIEW_Config_MicriumOSKernel.c
  group Source
    ../: ex_main.c
    ../common/common/: ex_common_init.c
    ../fs/: ex_fs.c ex_fs.h ex_fs_media_poll.c ex_fs_media_poll.h ex_fs_utils.h
    ../usb/host/: ex_usbh.c ex_usbh_msc.c
