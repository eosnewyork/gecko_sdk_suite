# Keil uVision project micriumos_usbdhidmouse.uvprojx, settings and files
target micriumos_usbdhidmouse (ARM-ADS)
  device: EFM32GG990F1024 Silicon Labs
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0-0xFFFFF) CLOCK(48000000) CPUTYPE("Cortex-M3")
  output: micriumos_usbdhidmouse
  AfterMake: fromelf.exe --bin --output obj\micriumos_usbdhidmouse.bin obj\micriumos_usbdhidmouse.axf
  c flags: Optim=1 oTime=1
  c define: EFM32GG990F1024 DEBUG_EFM RETARGET_VCOM
  c misc: --c99 --diag_suppress=C1296
  c include: ..\;..\..\..\..\..\platform\CMSIS\Include;..\..\..\..\..\platform\Device\SiliconLabs\EFM32GG\Include;..\..\..\..\..\platform\emlib\inc;..\..\..\..\..\hardware\kit\common\bsp;..\..\..\..\..\hardware\kit\common\drivers;..\..\..\..\..\hardware\kit\EFM32GG_STK3700\config;..\..\..\..\..\platform\micrium_os;..\..\..\..\..\platform\micrium_os\bsp\siliconlabs\generic\include;..\cfg;..;..\..\..\..\..\platform\micrium_os\rtos\cpu\include;..\..\..\..\..\platform\micrium_os\rtos\cpu\source\ports\armv7-m\armcc;..\..\..\..\..\util\third_party\segger\systemview\SEGGER;..\..\..\..\..\util\third_party\segger\systemview\Config;..\..\..\..\..\util\third_party\segger\systemview\Sample\MicriumOSKernel
  asm define: EFM32GG990F1024 DEBUG_EFM RETARGET_VCOM
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFM32GG/Source/ARM/: startup_efm32gg.s
    ../../../../../platform/Device/SiliconLabs/EFM32GG/Source/: system_efm32gg.c
  group bsp
    ../../../../../hardware/kit/common/bsp/: bsp_bcc.c bsp_stk.c bsp_stk_leds.c bsp_trace.c
    ../../../../../platform/micrium_os/bsp/siliconlabs/generic/source/: bsp_cpu.c bsp_os.c bsp_usb_dev.c
  group emlib
    ../../../../../platform/emlib/src/: em_assert.c em_cmu.c em_core.c em_ebi.c em_emu.c em_gpio.c em_system.c em_usart.c
  group common
    ../../../../../platform/micrium_os/common/source/auth/: auth.c
    ../../../../../platform/micrium_os/common/source/clk/: clk.c clk_cmd.c
    ../../../../../platform/micrium_os/common/source/collections/: bitmap.c map.c slist.c
    ../../../../../platform/micrium_os/common/source/common/: common.c
    ../../../../../platform/micrium_os/common/source/kal/: kal_kernel.c
    ../../../../../platform/micrium_os/common/source/lib/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../../../../../platform/micrium_os/common/source/rtos/: rtos_err_str.c
    ../../../../../platform/micrium_os/common/source/platform_mgr/: platform_mgr.c
  group cpu
    ../../../../../platform/micrium_os/cpu/source/: cpu_core.c
    ../../../../../platform/micrium_os/ports/source/armcc/: armv7m_cpu_a.asm
    ../../../../../platform/micrium_os/ports/source/generic/: armv6m_v7m_cpu_int.c
  group drivers
    ../../../../../platform/micrium_os/drivers/usb/source/device/: usbd_drv_dwc_otg_fs.c
    ../../../../../hardware/kit/common/drivers/: retargetio.c retargetserial.c
  group kernel
    ../../../../../platform/micrium_os/kernel/source/: os_core.c os_cfg_app.c os_dbg.c os_flag.c os_mem.c os_mon.c os_msg.c os_mutex.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
    ../../../../../platform/micrium_os/ports/source/armcc/: armv7m_os_cpu_a.asm armv7m_os_cpu_c.c
  group usb
    ../../../../../platform/micrium_os/usb/source/device/class/: usbd_hid.c usbd_hid_os.c usbd_hid_report.c
    ../../../../../platform/micrium_os/usb/source/device/core/: usbd_core.c usbd_ep.c usbd_os.c
    ../../../../../platform/micrium_os/usb/source/: usb_ctrlr.c
  group SystemView
    ../../../../../util/third_party/segger/systemview/SEGGER/: SEGGER_RTT.c SEGGER_SYSVIEW.c
    ../../../../../util/third_party/segger/systemview/Sample/MicriumOSKernel/: SEGGER_SYSVIEW_MicriumOSKernel.c
    ../cfg/: SEGGER_SYSVIEW_Config_MicriumOSKernel.c
  group Source
    ../: ex_main.c
    ../common/common/: ex_common_init.c
    ../usb/: ex_usbd_all.c ex_usbd_hid_mouse.c
