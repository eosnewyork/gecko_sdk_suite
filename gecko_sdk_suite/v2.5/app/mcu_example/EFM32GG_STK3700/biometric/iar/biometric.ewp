# IAR project biometric.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: EFM32GG990F1024 SiliconLaboratories EFM32GG990F1024
  ICCARM.CCDefines: EFM32GG990F1024; USB_DEBUG
  ICCARM.CCIncludePath2: ..\..\..\..\..\platform\CMSIS\Include; ..\..\..\..\..\platform\Device\SiliconLabs\EFM32GG\Include; ..\..\..\..\..\platform\emlib\inc; ..\..\..\..\..\hardware\kit\common\drivers; ..\..\..\..\..\hardware\kit\common\bsp; ..\..\..\..\..\hardware\kit\EFM32GG_STK3700\config; ..\usb; ..\..\..\..\..\platform\emdrv\rtcdrv\inc; ..\..\..\..\..\platform\emdrv\rtcdrv\config; ..\..\..\..\..\platform\emdrv\common\inc; ..\..\..\..\..\platform\emdrv\rtcdrv\config; ..\..\..\..\..\util\silicon_labs\sensor_si114xhrm\inc; ..\..\..\..\..\platform\middleware\usb_gecko\inc
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.ADefines: EFM32GG990F1024; USB_DEBUG
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: biometric.bin
  ILINK.IlinkOutputFile: biometric.out
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\util\silicon_labs\sensor_si114xhrm\lib\libsi114xHRM_IAR_CM3.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32GG990F1024; USB_DEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  group BSP
    ../../../../../hardware/kit/common/bsp/: bsp_bcc.c bsp_stk.c bsp_trace.c
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFM32GG/Source/IAR/: startup_efm32gg.s
    ../../../../../platform/Device/SiliconLabs/EFM32GG/Source/: system_efm32gg.c
  group Drivers
    ../../../../../hardware/kit/common/drivers/: segmentlcd.c i2cspm.c si7013.c si114x_functions.c si114x_sys_out.c si114x_uv_index.c
    ../../../../../platform/emdrv/rtcdrv/src/: rtcdriver.c
  group USB
    ../../../../../platform/middleware/usb_gecko/src/: em_usbd.c em_usbdch9.c em_usbdep.c em_usbhal.c em_usbtimer.c em_usbdint.c
    ../usb/: descriptors.c usb_debug.c
  group emlib
    ../../../../../platform/emlib/src/: em_adc.c em_assert.c em_cmu.c em_core.c em_dma.c em_ebi.c em_emu.c em_gpio.c em_lcd.c em_prs.c em_system.c em_timer.c em_usart.c em_rtc.c em_i2c.c
  group Source
    ../: biometric_demo.c heart_rate_monitor.c heart_rate_monitor.h heart_rate_monitor_config.h graphics.c graphics.h
