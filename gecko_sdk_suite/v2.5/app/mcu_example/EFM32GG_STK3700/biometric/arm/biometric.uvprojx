# Keil uVision project biometric.uvprojx, settings and files
target biometric (ARM-ADS)
  device: EFM32GG990F1024 Silicon Labs
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0-0xFFFFF) CLOCK(48000000) CPUTYPE("Cortex-M3")
  output: biometric
  AfterMake: fromelf.exe --bin --output obj\biometric.bin obj\biometric.axf
  c flags: Optim=4 oTime=1
  c define: EFM32GG990F1024 USB_DEBUG
  c misc: --c99
  c include: ..\;..\..\..\..\..\platform\CMSIS\Include;..\..\..\..\..\platform\Device\SiliconLabs\EFM32GG\Include;..\..\..\..\..\platform\emlib\inc;..\..\..\..\..\hardware\kit\common\drivers;..\..\..\..\..\hardware\kit\common\bsp;..\..\..\..\..\hardware\kit\EFM32GG_STK3700\config;..\usb;..\..\..\..\..\platform\emdrv\rtcdrv\inc;..\..\..\..\..\platform\emdrv\rtcdrv\config;..\..\..\..\..\platform\emdrv\common\inc;..\..\..\..\..\platform\emdrv\rtcdrv\config;..\..\..\..\..\util\silicon_labs\sensor_si114xhrm\inc;..\..\..\..\..\platform\middleware\usb_gecko\inc
  asm define: EFM32GG990F1024 USB_DEBUG
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group BSP
    ../../../../../hardware/kit/common/bsp/: bsp_bcc.c bsp_stk.c bsp_trace.c
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFM32GG/Source/ARM/: startup_efm32gg.s
    ../../../../../platform/Device/SiliconLabs/EFM32GG/Source/: system_efm32gg.c
  group Drivers
    ../../../../../hardware/kit/common/drivers/: segmentlcd.c i2cspm.c si7013.c si114x_functions.c si114x_sys_out.c si114x_uv_index.c
    ../../../../../platform/emdrv/rtcdrv/src/: rtcdriver.c
  group USB
    ../../../../../platform/middleware/usb_gecko/src/: em_usbd.c em_usbdch9.c em_usbdep.c em_usbhal.c em_usbtimer.c em_usbdint.c
    ../usb/: descriptors.c usb_debug.c
  group emlib
    ../../../../../platform/emlib/src/: em_adc.c em_assert.c em_cmu.c em_core.c em_dma.c em_ebi.c em_emu.c em_gpio.c em_lcd.c em_prs.c em_system.c em_timer.c em_usart.c em_rtc.c em_i2c.c
  group Source
    ../: biometric_demo.c heart_rate_monitor.c heart_rate_monitor.h heart_rate_monitor_config.h graphics.c graphics.h
  group Libraries
    ../../../../../util/silicon_labs/sensor_si114xhrm/lib/: si114xHRM_ARM_CM3.lib
