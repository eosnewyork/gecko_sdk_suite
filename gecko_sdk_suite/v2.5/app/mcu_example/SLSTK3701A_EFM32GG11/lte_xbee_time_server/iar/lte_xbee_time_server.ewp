# IAR project lte_xbee_time_server.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32GG11B820F2048GL192 SiliconLaboratories EFM32GG11B820F2048GL192
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: EFM32GG11B820F2048GL192; DEBUG_EFM; XBEE_PLATFORM_HEADER="xbee/platform_efm32.h"; XBEE_CELLULAR_ENABLED=1; XBEE_DEVICE_ENABLE_ATMODE=1; XBEE_DEMO_CONFIG; XBEE_DEMO_HOLOGRAM_SIM; XBEE_CHANGE_APN; XBEE_TARGET_APN="hologram"
  ICCARM.CCIncludePath2: ..\..\..\..\..\platform\CMSIS\Include; ..\..\..\..\..\platform\Device\SiliconLabs\EFM32GG11B\Include; ..\..\..\..\..\platform\emlib\inc; ..\..\..\..\..\hardware\kit\common\drivers; ..\..\..\..\..\hardware\kit\common\bsp; ..\..\..\..\..\hardware\kit\SLSTK3701A_EFM32GG11\config; ..; ..\..\..\..\..\platform\middleware\glib; ..\..\..\..\..\util\third_party\digi_lte\xbee\inc; ..\..\..\..\..\util\third_party\digi_lte\xbee\src\efm32; ..\..\..\..\..\util\third_party\digi_lte\xbee\config\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: lte_xbee_time_server.bin
  ILINK.IlinkOutputFile: lte_xbee_time_server.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32GG11B820F2048GL192; DEBUG_EFM; XBEE_PLATFORM_HEADER="xbee/platform_efm32.h"; XBEE_CELLULAR_ENABLED=1; XBEE_DEVICE_ENABLE_ATMODE=1; XBEE_DEMO_CONFIG; XBEE_DEMO_HOLOGRAM_SIM; XBEE_CHANGE_APN; XBEE_TARGET_APN="hologram"
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFM32GG11B/Source/IAR/: startup_efm32gg11b.s
    ../../../../../platform/Device/SiliconLabs/EFM32GG11B/Source/: system_efm32gg11b.c
  group Drivers
    ../../../../../hardware/kit/common/drivers/: retargetio.c retargettextdisplay.c textdisplay.c display.c displayls013b7dh06.c displaypalemlib.c udelay.c
  group emlib
    ../../../../../platform/emlib/src/: em_assert.c em_cmu.c em_core.c em_emu.c em_gpio.c em_prs.c em_rtcc.c em_system.c em_usart.c
  group Source
    ../: main.c readme.txt
  group XBee
    ../../../../../util/third_party/digi_lte/xbee/src/xbee/: xbee_atcmd.c xbee_atmode.c xbee_cbuf.c xbee_device.c xbee_ipv4.c
    ../../../../../util/third_party/digi_lte/xbee/src/efm32/: xbee_platform_efm32.c xbee_serial_efm32.c
    ../../../../../util/third_party/digi_lte/xbee/src/util/: hexdump.c hexstrtobyte.c jslong.c memcheck.c swapbytes.c swapcpy.c xmodem_crc16.c
    ../../../../../util/third_party/digi_lte/xbee/src/wpan/: wpan_types.c
    ../../../../../util/third_party/digi_lte/xbee/config/src/: xbee_config.c
