# Keil uVision project persistent_trng.uvprojx, settings and files
target persistent_trng (ARM-ADS)
  device: EFM32GG11B820F2048GL192 Silicon Labs
  cpu: IRAM(0x20000000-0x2007FFFF) IROM(0-0x1FFFFF) CLOCK(38400000) CPUTYPE("Cortex-M4") FPU2
  output: persistent_trng
  AfterMake: fromelf.exe --bin --output obj\persistent_trng.bin obj\persistent_trng.axf
  c flags: Optim=1 oTime=1 uC99=1 wLevel=2
  c define: EFM32GG11B820F2048GL192 DEBUG_EFM
  c misc: -DMBEDTLS_CONFIG_FILE='"config-trng.h"'
  c include: ..\;..\..\..\..\..\platform\CMSIS\Include;..\..\..\..\..\platform\Device\SiliconLabs\EFM32GG11B\Include;..\..\..\..\..\platform\emlib\inc;..\..\..\..\..\platform\emdrv\nvm3\inc;..\..\..\..\..\platform\emdrv\rtcdrv\inc;..\..\..\..\..\platform\emdrv\rtcdrv\config;..\..\..\..\..\platform\emdrv\common\inc;..\..\..\..\..\hardware\kit\common\bsp;..\..\..\..\..\hardware\kit\SLSTK3701A_EFM32GG11\config;..;..\..\..\..\..\platform\middleware\glib;..\..\..\..\..\hardware\kit\common\drivers;..\..\..\..\..\util\third_party\mbedtls\include;..\..\..\..\..\util\third_party\mbedtls\include\mbedtls;..\..\..\..\..\util\third_party\mbedtls\sl_crypto\include;..\..\..\..\..\util\third_party\mbedtls\sl_crypto\src
  asm define: EFM32GG11B820F2048GL192 DEBUG_EFM
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
  scatter file: ..\persistent_trng.sct
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFM32GG11B/Source/ARM/: startup_efm32gg11b.s
    ../../../../../platform/Device/SiliconLabs/EFM32GG11B/Source/: system_efm32gg11b.c
  group BSP
    ../../../../../hardware/kit/common/bsp/: bsp_bcc.c bsp_stk.c bsp_stk_leds.c bsp_trace.c
  group Drivers
    ../../../../../hardware/kit/common/drivers/: retargetio.c retargettextdisplay.c textdisplay.c display.c displayls013b7dh06.c displaypalemlib.c udelay.c
  group EMLIB
    ../../../../../platform/emlib/src/: em_assert.c em_crypto.c em_cmu.c em_ebi.c em_emu.c em_gpio.c em_system.c em_usart.c em_core.c em_msc.c em_rtcc.c em_prs.c
  group NVM3
    ../../../../../platform/emdrv/nvm3/src/: nvm3_hal_flash.c nvm3_lock.c
  group mbedTLS
    ../../../../../util/third_party/mbedtls/library/: sha256.c bignum.c ctr_drbg.c entropy.c entropy_poll.c error.c platform.c version.c version_features.c
  group sl_crypto
    ../../../../../util/third_party/mbedtls/sl_crypto/src/: crypto_aes.c crypto_management.c trng.c crypto_sha.c shax.c
  group RTCDRV
    ../../../../../platform/emdrv/rtcdrv/src/: rtcdriver.c
  group Source
    ../: main.c
  group Libraries
    ../../../../../platform/emdrv/nvm3/lib/: libnvm3_CM4_keil.lib
