<?xml version="1.0" encoding="UTF-8" standalone="no" ?>
<ProjectOpt xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:noNamespaceSchemaLocation="project_opt.xsd">

  <SchemaVersion>1.0</SchemaVersion>

  <Header>### uVision Project, (C) Keil Software</Header>

  <Extensions>
    <cExt>*.c</cExt>
    <aExt>*.s*; *.src; *.a*</aExt>
    <oExt>*.obj</oExt>
    <lExt>*.lib</lExt>
    <tExt>*.txt; *.h; *.inc</tExt>
    <pExt>*.plm</pExt>
    <CppX>*.cpp</CppX>
  </Extensions>

  <DaveTm>
    <dwLowDateTime>0</dwLowDateTime>
    <dwHighDateTime>0</dwHighDateTime>
  </DaveTm>

  <Target>
    <TargetName>micriumos_net</TargetName>
    <ToolsetNumber>0x4</ToolsetNumber>
    <ToolsetName>ARM-ADS</ToolsetName>
    <TargetOption>
      <CLKADS>38400000</CLKADS>
      <OPTTT>
        <gFlags>1</gFlags>
        <BeepAtEnd>1</BeepAtEnd>
        <RunSim>1</RunSim>
        <RunTarget>0</RunTarget>
      </OPTTT>
      <OPTHX>
        <HexSelection>1</HexSelection>
        <FlashByte>65535</FlashByte>
        <HexRangeLowAddress>0</HexRangeLowAddress>
        <HexRangeHighAddress>0</HexRangeHighAddress>
        <HexOffset>0</HexOffset>
      </OPTHX>
      <OPTLEX>
        <PageWidth>79</PageWidth>
        <PageLength>66</PageLength>
        <TabStop>8</TabStop>
        <ListingPath>.\lst\</ListingPath>
      </OPTLEX>
      <ListingPage>
        <CreateCListing>1</CreateCListing>
        <CreateAListing>1</CreateAListing>
        <CreateLListing>1</CreateLListing>
        <CreateIListing>0</CreateIListing>
        <AsmCond>1</AsmCond>
        <AsmSymb>1</AsmSymb>
        <AsmXref>0</AsmXref>
        <CCond>1</CCond>
        <CCode>0</CCode>
        <CListInc>0</CListInc>
        <CSymb>0</CSymb>
        <LinkerCodeListing>0</LinkerCodeListing>
      </ListingPage>
      <OPTXL>
        <LMap>1</LMap>
        <LComments>1</LComments>
        <LGenerateSymbols>1</LGenerateSymbols>
        <LLibSym>1</LLibSym>
        <LLines>1</LLines>
        <LLocSym>1</LLocSym>
        <LPubSym>1</LPubSym>
        <LXref>0</LXref>
        <LExpSel>0</LExpSel>
      </OPTXL>
      <OPTFL>
        <tvExp>1</tvExp>
        <tvExpOptDlg>0</tvExpOptDlg>
        <IsCurrentTarget>1</IsCurrentTarget>
      </OPTFL>
      <CpuCode>255</CpuCode>
      <DllOpt>
        <SimDllName>SARMCM3.DLL</SimDllName>
        <SimDllArguments></SimDllArguments>
        <SimDlgDllName>DCM.DLL</SimDlgDllName>
        <SimDlgDllArguments>-pCM4</SimDlgDllArguments>
        <TargetDllName>SARMCM3.DLL</TargetDllName>
        <TargetDllArguments></TargetDllArguments>
        <TargetDlgDllName>TCM.DLL</TargetDlgDllName>
        <TargetDlgDllArguments>-pCM4</TargetDlgDllArguments>
      </DllOpt>
      <DebugOpt>
        <uSim>0</uSim>
        <uTrg>1</uTrg>
        <sLdApp>1</sLdApp>
        <sGomain>1</sGomain>
        <sRbreak>1</sRbreak>
        <sRwatch>1</sRwatch>
        <sRmem>1</sRmem>
        <sRfunc>1</sRfunc>
        <sRbox>1</sRbox>
        <tLdApp>1</tLdApp>
        <tGomain>1</tGomain>
        <tRbreak>1</tRbreak>
        <tRwatch>1</tRwatch>
        <tRmem>1</tRmem>
        <tRfunc>0</tRfunc>
        <tRbox>1</tRbox>
        <sRunDeb>0</sRunDeb>
        <sLrtime>0</sLrtime>
        <nTsel>7</nTsel>
        <sDll></sDll>
        <sDllPa></sDllPa>
        <sDlgDll></sDlgDll>
        <sDlgPa></sDlgPa>
        <sIfile></sIfile>
        <tDll></tDll>
        <tDllPa></tDllPa>
        <tDlgDll></tDlgDll>
        <tDlgPa></tDlgPa>
        <tIfile></tIfile>
        <pMon>Segger\JL2CM3.dll</pMon>
      </DebugOpt>
      <TargetDriverDllRegistry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>UL2CM3</Key>
          <Name>-O206 -S0 -C0 -FO7 -FD20000000 -FC8000 -FN1 -FS00 -FL040000 -FP0($$Device:EFM32GG11B820F2048GL192$Flash\GECKOG1.FLM)</Name>
        </SetRegEntry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>DLGTARM</Key>
          <Name>(1010=-1,-1,-1,-1,0)(1007=-1,-1,-1,-1,0)(1008=-1,-1,-1,-1,0)(1009=-1,-1,-1,-1,0)</Name>
        </SetRegEntry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>ARMDBGFLAGS</Key>
          <Name></Name>
        </SetRegEntry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>DLGUARM</Key>
          <Name>(106=-1,-1,-1,-1,0)(107=-1,-1,-1,-1,0)</Name>
        </SetRegEntry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>JL2CM3</Key>
          <Name>-U440000000 -O206 -S0 -A0 -C0 -JU1 -JI127.0.0.1 -JP0 -RST0 -N00("ARM CoreSight SW-DP") -D00(2BA01477) -L00(0) -TO18 -TC10000000 -TP21 -TDS8007 -TDT0 -TDC1F -TIEFFFFFFFF -TIP8 -TB1 -TFE0 -FO7 -FD20000000 -FC8000 -FN1 -FS00 -FL040000 -FP0($$Device:EFM32GG11B820F2048GL192$Flash\GECKOG1.FLM)</Name>
        </SetRegEntry>
      </TargetDriverDllRegistry>
      <DebugFlag>
        <trace>0</trace>
        <periodic>0</periodic>
        <aLwin>1</aLwin>
        <aCover>0</aCover>
        <aSer1>0</aSer1>
        <aSer2>0</aSer2>
        <aPa>0</aPa>
        <viewmode>1</viewmode>
        <vrSel>0</vrSel>
        <aSym>0</aSym>
        <aTbox>0</aTbox>
        <AscS1>0</AscS1>
        <AscS2>0</AscS2>
        <AscS3>0</AscS3>
        <aSer3>0</aSer3>
        <eProf>0</eProf>
        <aLa>0</aLa>
        <aPa1>0</aPa1>
        <AscS4>0</AscS4>
        <aSer4>0</aSer4>
        <StkLoc>0</StkLoc>
        <TrcWin>0</TrcWin>
        <newCpu>2</newCpu>
        <uProt>0</uProt>
      </DebugFlag>
      <LintExecutable></LintExecutable>
      <LintConfigFile></LintConfigFile>
    </TargetOption>
  </Target>
  
        <Group>
          <GroupName>CMSIS</GroupName>
          <Files>
            <File>
              <FileName>startup_efm32gg11b.s</FileName>
              <FileType>2</FileType>
              <FilePath>..\..\..\..\..\platform\Device\SiliconLabs\EFM32GG11B\Source\ARM\startup_efm32gg11b.s</FilePath>
            </File>
            <File>
              <FileName>system_efm32gg11b.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\Device\SiliconLabs\EFM32GG11B\Source\system_efm32gg11b.c</FilePath>
            </File>
          </Files>
        </Group>
        <Group>
          <GroupName>bsp</GroupName>
          <Files>
            <File>
              <FileName>bsp_bcc.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\hardware\kit\common\bsp\bsp_bcc.c</FilePath>
            </File>
            <File>
              <FileName>bsp_stk.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\hardware\kit\common\bsp\bsp_stk.c</FilePath>
            </File>
            <File>
              <FileName>bsp_stk_leds.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\hardware\kit\common\bsp\bsp_stk_leds.c</FilePath>
            </File>
            <File>
              <FileName>bsp_trace.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\hardware\kit\common\bsp\bsp_trace.c</FilePath>
            </File>
            <File>
              <FileName>bsp_cpu.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\micrium_os\bsp\siliconlabs\generic\source\bsp_cpu.c</FilePath>
            </File>
            <File>
              <FileName>bsp_os.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\micrium_os\bsp\siliconlabs\generic\source\bsp_os.c</FilePath>
            </File>
            <File>
              <FileName>bsp_net_ether_gem.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\micrium_os\bsp\siliconlabs\generic\source\bsp_net_ether_gem.c</FilePath>
            </File>
          </Files>
        </Group>
        <Group>
          <GroupName>emlib</GroupName>
          <Files>
            <File>
              <FileName>em_assert.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\emlib\src\em_assert.c</FilePath>
            </File>
            <File>
              <FileName>em_cmu.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\emlib\src\em_cmu.c</FilePath>
            </File>
            <File>
              <FileName>em_core.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\emlib\src\em_core.c</FilePath>
            </File>
            <File>
              <FileName>em_emu.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\emlib\src\em_emu.c</FilePath>
            </File>
            <File>
              <FileName>em_gpio.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\emlib\src\em_gpio.c</FilePath>
            </File>
            <File>
              <FileName>em_prs.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\emlib\src\em_prs.c</FilePath>
            </File>
            <File>
              <FileName>em_rtcc.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\emlib\src\em_rtcc.c</FilePath>
            </File>
            <File>
              <FileName>em_system.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\emlib\src\em_system.c</FilePath>
            </File>
            <File>
              <FileName>em_usart.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\emlib\src\em_usart.c</FilePath>
            </File>
          </Files>
        </Group>
        <Group>
          <GroupName>common</GroupName>
          <Files>
            <File>
              <FileName>auth.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\micrium_os\common\source\auth\auth.c</FilePath>
            </File>
            <File>
              <FileName>clk.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\micrium_os\common\source\clk\clk.c</FilePath>
            </File>
            <File>
              <FileName>clk_cmd.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\micrium_os\common\source\clk\clk_cmd.c</FilePath>
            </File>
            <File>
              <FileName>bitmap.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\micrium_os\common\source\collections\bitmap.c</FilePath>
            </File>
            <File>
              <FileName>map.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\micrium_os\common\source\collections\map.c</FilePath>
            </File>
            <File>
              <FileName>slist.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\micrium_os\common\source\collections\slist.c</FilePath>
            </File>
            <File>
              <FileName>common.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\micrium_os\common\source\common\common.c</FilePath>
            </File>
            <File>
              <FileName>kal_kernel.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\micrium_os\common\source\kal\kal_kernel.c</FilePath>
            </File>
            <File>
              <FileName>lib_ascii.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\micrium_os\common\source\lib\lib_ascii.c</FilePath>
            </File>
            <File>
              <FileName>lib_math.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\micrium_os\common\source\lib\lib_math.c</FilePath>
            </File>
            <File>
              <FileName>lib_mem.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\micrium_os\common\source\lib\lib_mem.c</FilePath>
            </File>
            <File>
              <FileName>lib_str.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\micrium_os\common\source\lib\lib_str.c</FilePath>
            </File>
            <File>
              <FileName>rtos_err_str.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\micrium_os\common\source\rtos\rtos_err_str.c</FilePath>
            </File>
            <File>
              <FileName>platform_mgr.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\micrium_os\common\source\platform_mgr\platform_mgr.c</FilePath>
            </File>
          </Files>
        </Group>
        <Group>
          <GroupName>cpu</GroupName>
          <Files>
            <File>
              <FileName>cpu_core.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\micrium_os\cpu\source\cpu_core.c</FilePath>
            </File>
            <File>
              <FileName>armv7m_cpu_a.asm</FileName>
              <FileType>2</FileType>
              <FilePath>..\..\..\..\..\platform\micrium_os\ports\source\armcc\armv7m_cpu_a.asm</FilePath>
            </File>
            <File>
              <FileName>armv6m_v7m_cpu_int.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\micrium_os\ports\source\generic\armv6m_v7m_cpu_int.c</FilePath>
            </File>
          </Files>
        </Group>
        <Group>
          <GroupName>drivers</GroupName>
          <Files>
            <File>
              <FileName>net_drv_ether_gem.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\micrium_os\drivers\net\source\net_drv_ether_gem.c</FilePath>
            </File>
            <File>
              <FileName>net_drv_phy_generic.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\micrium_os\drivers\net\source\net_drv_phy_generic.c</FilePath>
            </File>
            <File>
              <FileName>retargetio.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\hardware\kit\common\drivers\retargetio.c</FilePath>
            </File>
            <File>
              <FileName>retargetserial.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\hardware\kit\common\drivers\retargetserial.c</FilePath>
            </File>
            <File>
              <FileName>display.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\hardware\kit\common\drivers\display.c</FilePath>
            </File>
            <File>
              <FileName>displayls013b7dh06.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\hardware\kit\common\drivers\displayls013b7dh06.c</FilePath>
            </File>
            <File>
              <FileName>displaypalemlib.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\hardware\kit\common\drivers\displaypalemlib.c</FilePath>
            </File>
            <File>
              <FileName>udelay.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\hardware\kit\common\drivers\udelay.c</FilePath>
            </File>
          </Files>
        </Group>
        <Group>
          <GroupName>glib</GroupName>
          <Files>
            <File>
              <FileName>dmd_display.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\middleware\glib\dmd\display\dmd_display.c</FilePath>
            </File>
            <File>
              <FileName>glib.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\middleware\glib\glib\glib.c</FilePath>
            </File>
            <File>
              <FileName>glib_bitmap.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\middleware\glib\glib\glib_bitmap.c</FilePath>
            </File>
            <File>
              <FileName>glib_circle.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\middleware\glib\glib\glib_circle.c</FilePath>
            </File>
            <File>
              <FileName>glib_line.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\middleware\glib\glib\glib_line.c</FilePath>
            </File>
            <File>
              <FileName>glib_polygon.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\middleware\glib\glib\glib_polygon.c</FilePath>
            </File>
            <File>
              <FileName>glib_rectangle.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\middleware\glib\glib\glib_rectangle.c</FilePath>
            </File>
            <File>
              <FileName>glib_string.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\middleware\glib\glib\glib_string.c</FilePath>
            </File>
            <File>
              <FileName>glib_font_normal_8x8.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\middleware\glib\glib\glib_font_normal_8x8.c</FilePath>
            </File>
            <File>
              <FileName>glib_font_narrow_6x8.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\middleware\glib\glib\glib_font_narrow_6x8.c</FilePath>
            </File>
            <File>
              <FileName>glib_font_number_16x20.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\middleware\glib\glib\glib_font_number_16x20.c</FilePath>
            </File>
          </Files>
        </Group>
        <Group>
          <GroupName>kernel</GroupName>
          <Files>
            <File>
              <FileName>os_core.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\micrium_os\kernel\source\os_core.c</FilePath>
            </File>
            <File>
              <FileName>os_cfg_app.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\micrium_os\kernel\source\os_cfg_app.c</FilePath>
            </File>
            <File>
              <FileName>os_dbg.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\micrium_os\kernel\source\os_dbg.c</FilePath>
            </File>
            <File>
              <FileName>os_flag.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\micrium_os\kernel\source\os_flag.c</FilePath>
            </File>
            <File>
              <FileName>os_mem.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\micrium_os\kernel\source\os_mem.c</FilePath>
            </File>
            <File>
              <FileName>os_mon.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\micrium_os\kernel\source\os_mon.c</FilePath>
            </File>
            <File>
              <FileName>os_msg.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\micrium_os\kernel\source\os_msg.c</FilePath>
            </File>
            <File>
              <FileName>os_mutex.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\micrium_os\kernel\source\os_mutex.c</FilePath>
            </File>
            <File>
              <FileName>os_prio.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\micrium_os\kernel\source\os_prio.c</FilePath>
            </File>
            <File>
              <FileName>os_q.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\micrium_os\kernel\source\os_q.c</FilePath>
            </File>
            <File>
              <FileName>os_sem.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\micrium_os\kernel\source\os_sem.c</FilePath>
            </File>
            <File>
              <FileName>os_stat.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\micrium_os\kernel\source\os_stat.c</FilePath>
            </File>
            <File>
              <FileName>os_task.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\micrium_os\kernel\source\os_task.c</FilePath>
            </File>
            <File>
              <FileName>os_tick.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\micrium_os\kernel\source\os_tick.c</FilePath>
            </File>
            <File>
              <FileName>os_time.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\micrium_os\kernel\source\os_time.c</FilePath>
            </File>
            <File>
              <FileName>os_tmr.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\micrium_os\kernel\source\os_tmr.c</FilePath>
            </File>
            <File>
              <FileName>os_var.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\micrium_os\kernel\source\os_var.c</FilePath>
            </File>
            <File>
              <FileName>armv7m_os_cpu_a.asm</FileName>
              <FileType>2</FileType>
              <FilePath>..\..\..\..\..\platform\micrium_os\ports\source\armcc\armv7m_os_cpu_a.asm</FilePath>
            </File>
            <File>
              <FileName>armv7m_os_cpu_c.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\micrium_os\ports\source\armcc\armv7m_os_cpu_c.c</FilePath>
            </File>
          </Files>
        </Group>
        <Group>
          <GroupName>SystemView</GroupName>
          <Files>
            <File>
              <FileName>SEGGER_RTT.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\util\third_party\segger\systemview\SEGGER\SEGGER_RTT.c</FilePath>
            </File>
            <File>
              <FileName>SEGGER_SYSVIEW.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\util\third_party\segger\systemview\SEGGER\SEGGER_SYSVIEW.c</FilePath>
            </File>
            <File>
              <FileName>SEGGER_SYSVIEW_MicriumOSKernel.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\util\third_party\segger\systemview\Sample\MicriumOSKernel\SEGGER_SYSVIEW_MicriumOSKernel.c</FilePath>
            </File>
            <File>
              <FileName>SEGGER_SYSVIEW_Config_MicriumOSKernel.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\cfg\SEGGER_SYSVIEW_Config_MicriumOSKernel.c</FilePath>
            </File>
          </Files>
        </Group>
        <Group>
          <GroupName>net</GroupName>
          <Files>
            <File>
              <FileName>net.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\micrium_os\net\source\tcpip\net.c</FilePath>
            </File>
            <File>
              <FileName>net_app.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\micrium_os\net\source\tcpip\net_app.c</FilePath>
            </File>
            <File>
              <FileName>net_arp.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\micrium_os\net\source\tcpip\net_arp.c</FilePath>
            </File>
            <File>
              <FileName>net_ascii.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\micrium_os\net\source\tcpip\net_ascii.c</FilePath>
            </File>
            <File>
              <FileName>net_bsd.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\micrium_os\net\source\tcpip\net_bsd.c</FilePath>
            </File>
            <File>
              <FileName>net_buf.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\micrium_os\net\source\tcpip\net_buf.c</FilePath>
            </File>
            <File>
              <FileName>net_cache.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\micrium_os\net\source\tcpip\net_cache.c</FilePath>
            </File>
            <File>
              <FileName>net_conn.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\micrium_os\net\source\tcpip\net_conn.c</FilePath>
            </File>
            <File>
              <FileName>net_ctr.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\micrium_os\net\source\tcpip\net_ctr.c</FilePath>
            </File>
            <File>
              <FileName>net_dad.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\micrium_os\net\source\tcpip\net_dad.c</FilePath>
            </File>
            <File>
              <FileName>net_icmp.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\micrium_os\net\source\tcpip\net_icmp.c</FilePath>
            </File>
            <File>
              <FileName>net_icmpv4.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\micrium_os\net\source\tcpip\net_icmpv4.c</FilePath>
            </File>
            <File>
              <FileName>net_icmpv6.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\micrium_os\net\source\tcpip\net_icmpv6.c</FilePath>
            </File>
            <File>
              <FileName>net_if.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\micrium_os\net\source\tcpip\net_if.c</FilePath>
            </File>
            <File>
              <FileName>net_if_802x.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\micrium_os\net\source\tcpip\net_if_802x.c</FilePath>
            </File>
            <File>
              <FileName>net_if_ether.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\micrium_os\net\source\tcpip\net_if_ether.c</FilePath>
            </File>
            <File>
              <FileName>net_if_loopback.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\micrium_os\net\source\tcpip\net_if_loopback.c</FilePath>
            </File>
            <File>
              <FileName>net_if_wifi.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\micrium_os\net\source\tcpip\net_if_wifi.c</FilePath>
            </File>
            <File>
              <FileName>net_igmp.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\micrium_os\net\source\tcpip\net_igmp.c</FilePath>
            </File>
            <File>
              <FileName>net_ip.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\micrium_os\net\source\tcpip\net_ip.c</FilePath>
            </File>
            <File>
              <FileName>net_ipv4.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\micrium_os\net\source\tcpip\net_ipv4.c</FilePath>
            </File>
            <File>
              <FileName>net_ipv6.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\micrium_os\net\source\tcpip\net_ipv6.c</FilePath>
            </File>
            <File>
              <FileName>net_mldp.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\micrium_os\net\source\tcpip\net_mldp.c</FilePath>
            </File>
            <File>
              <FileName>net_ndp.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\micrium_os\net\source\tcpip\net_ndp.c</FilePath>
            </File>
            <File>
              <FileName>net_sock.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\micrium_os\net\source\tcpip\net_sock.c</FilePath>
            </File>
            <File>
              <FileName>net_stat.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\micrium_os\net\source\tcpip\net_stat.c</FilePath>
            </File>
            <File>
              <FileName>net_task.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\micrium_os\net\source\tcpip\net_task.c</FilePath>
            </File>
            <File>
              <FileName>net_tcp.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\micrium_os\net\source\tcpip\net_tcp.c</FilePath>
            </File>
            <File>
              <FileName>net_tmr.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\micrium_os\net\source\tcpip\net_tmr.c</FilePath>
            </File>
            <File>
              <FileName>net_udp.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\micrium_os\net\source\tcpip\net_udp.c</FilePath>
            </File>
            <File>
              <FileName>net_util.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\micrium_os\net\source\tcpip\net_util.c</FilePath>
            </File>
            <File>
              <FileName>net_wifi_mgr.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\micrium_os\net\source\tcpip\net_wifi_mgr.c</FilePath>
            </File>
            <File>
              <FileName>net_base64.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\micrium_os\net\source\util\net_base64.c</FilePath>
            </File>
            <File>
              <FileName>net_dict.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\micrium_os\net\source\util\net_dict.c</FilePath>
            </File>
            <File>
              <FileName>net_fs_port_native.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\micrium_os\net\source\util\net_fs_port_native.c</FilePath>
            </File>
            <File>
              <FileName>net_sha1.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\micrium_os\net\source\util\net_sha1.c</FilePath>
            </File>
            <File>
              <FileName>net_svc_task.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\micrium_os\net\source\util\net_svc_task.c</FilePath>
            </File>
            <File>
              <FileName>dhcp.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\micrium_os\net\source\dhcp\dhcp.c</FilePath>
            </File>
            <File>
              <FileName>dhcp_client.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\micrium_os\net\source\dhcp\dhcp_client.c</FilePath>
            </File>
            <File>
              <FileName>dns_client.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\micrium_os\net\source\dns\dns_client.c</FilePath>
            </File>
            <File>
              <FileName>dns_client_cache.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\micrium_os\net\source\dns\dns_client_cache.c</FilePath>
            </File>
            <File>
              <FileName>dns_client_req.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\micrium_os\net\source\dns\dns_client_req.c</FilePath>
            </File>
            <File>
              <FileName>dns_client_task.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\micrium_os\net\source\dns\dns_client_task.c</FilePath>
            </File>
          </Files>
        </Group>
        <Group>
          <GroupName>Source</GroupName>
          <Files>
            <File>
              <FileName>ex_main.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\ex_main.c</FilePath>
            </File>
            <File>
              <FileName>ex_common_init.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\common\common\ex_common_init.c</FilePath>
            </File>
            <File>
              <FileName>ex_network.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\net\ex_network.c</FilePath>
            </File>
            <File>
              <FileName>ex_net_core.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\net\core\ex_net_core.c</FilePath>
            </File>
            <File>
              <FileName>graphics.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\graphics.c</FilePath>
            </File>
          </Files>
        </Group>

</ProjectOpt>
