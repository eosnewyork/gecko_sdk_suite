# Keil uVision project lte_xbee_device_cloud.uvprojx, settings and files
target lte_xbee_device_cloud (ARM-ADS)
  device: EFM32GG11B820F2048GL192 Silicon Labs
  cpu: IRAM(0x20000000-0x2007FFFF) IROM(0-0x1FFFFF) CLOCK(38400000) CPUTYPE("Cortex-M4") FPU2
  output: lte_xbee_device_cloud
  AfterMake: fromelf.exe --bin --output obj\lte_xbee_device_cloud.bin obj\lte_xbee_device_cloud.axf
  c flags: Optim=4 oTime=1 uC99=1 wLevel=2
  c define: EFM32GG11B820F2048GL192 DEBUG_EFM XBEE_CELLULAR_ENABLED=1 XBEE_DEVICE_ENABLE_ATMODE=1 XBEE_DEMO_CONFIG XBEE_DEMO_HOLOGRAM_SIM XBEE_CHANGE_APN EFM32_MICRIUM
  c misc: -DXBEE_PLATFORM_HEADER='"xbee/platform_efm32.h"' -DXBEE_TARGET_APN='"hologram"' -DUSER='"user"' -DPWD='"password"' --diag_suppress=C1296
  c include: ..\;..\..\..\..\..\platform\CMSIS\Include;..\..\..\..\..\platform\Device\SiliconLabs\EFM32GG11B\Include;..\..\..\..\..\platform\emlib\inc;..\..\..\..\..\hardware\kit\common\drivers;..\..\..\..\..\hardware\kit\common\bsp;..\..\..\..\..\hardware\kit\SLSTK3701A_EFM32GG11\config;..;..\..\..\..\..\platform\middleware\glib;..\..\..\..\..\platform\micrium_os;..\..\..\..\..\platform\micrium_os\bsp\siliconlabs\generic\include;..\cfg;..\..\..\..\..\util\third_party\digi_lte\xbee\inc;..\..\..\..\..\util\third_party\digi_lte\xbee\src\efm32;..\..\..\..\..\util\third_party\digi_lte\xbee\config\inc;..\..\..\..\..\platform\micrium_os\rtos\cpu\include;..\..\..\..\..\util\third_party\segger\systemview\SEGGER;..\..\..\..\..\util\third_party\segger\systemview\Config;..\..\..\..\..\util\third_party\segger\systemview\Sample\MicriumOSKernel
  asm define: as above
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFM32GG11B/Source/ARM/: startup_efm32gg11b.s
    ../../../../../platform/Device/SiliconLabs/EFM32GG11B/Source/: system_efm32gg11b.c
  group bsp
    ../../../../../hardware/kit/common/bsp/: bsp_bcc.c bsp_stk.c bsp_stk_leds.c bsp_trace.c
    ../../../../../platform/micrium_os/bsp/siliconlabs/generic/source/: bsp_cpu.c bsp_os.c
  group Drivers
    ../../../../../hardware/kit/common/drivers/: retargetio.c retargettextdisplay.c textdisplay.c display.c displayls013b7dh06.c displaypalemlib.c udelay.c i2cspm.c si7013.c
  group emlib
    ../../../../../platform/emlib/src/: em_assert.c em_cmu.c em_core.c em_ebi.c em_emu.c em_gpio.c em_i2c.c em_prs.c em_rtcc.c em_system.c em_timer.c em_usart.c
  group common
    ../../../../../platform/micrium_os/common/source/auth/: auth.c
    ../../../../../platform/micrium_os/common/source/clk/: clk.c clk_cmd.c
    ../../../../../platform/micrium_os/common/source/collections/: bitmap.c map.c slist.c
    ../../../../../platform/micrium_os/common/source/common/: common.c
    ../../../../../platform/micrium_os/common/source/kal/: kal_kernel.c
    ../../../../../platform/micrium_os/common/source/lib/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../../../../../platform/micrium_os/common/source/rtos/: rtos_err_str.c
    ../../../../../platform/micrium_os/common/source/platform_mgr/: platform_mgr.c
  group cfg
    ../cfg/: bsp_cfg.h common_cfg.h cpu_cfg.h os_cfg.h rtos_cfg.h rtos_description.h rtos_err_cfg.h
  group cpu
    ../../../../../platform/micrium_os/cpu/source/: cpu_core.c
    ../../../../../platform/micrium_os/ports/source/armcc/: armv7m_cpu_a.asm
    ../../../../../platform/micrium_os/ports/source/generic/: armv6m_v7m_cpu_int.c
  group kernel
    ../../../../../platform/micrium_os/kernel/source/: os_core.c os_cfg_app.c os_dbg.c os_flag.c os_mem.c os_mon.c os_msg.c os_mutex.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
    ../../../../../platform/micrium_os/ports/source/armcc/: armv7m_os_cpu_a.asm armv7m_os_cpu_c.c
  group SystemView
    ../../../../../util/third_party/segger/systemview/SEGGER/: SEGGER_RTT.c SEGGER_SYSVIEW.c
    ../../../../../util/third_party/segger/systemview/Sample/MicriumOSKernel/: SEGGER_SYSVIEW_MicriumOSKernel.c
    ../cfg/: SEGGER_SYSVIEW_Config_MicriumOSKernel.c
  group Source
    ../: gnss.c http_client.c leds.c main.c readme.txt temp_sensor.c
  group XBee
    ../../../../../util/third_party/digi_lte/xbee/src/xbee/: xbee_atcmd.c xbee_atmode.c xbee_cbuf.c xbee_device.c xbee_ipv4.c
    ../../../../../util/third_party/digi_lte/xbee/src/efm32/: xbee_platform_efm32.c xbee_serial_efm32.c
    ../../../../../util/third_party/digi_lte/xbee/src/util/: hexdump.c hexstrtobyte.c jslong.c memcheck.c swapbytes.c swapcpy.c xmodem_crc16.c
    ../../../../../util/third_party/digi_lte/xbee/src/wpan/: wpan_types.c
    ../../../../../util/third_party/digi_lte/xbee/config/src/: xbee_config.c
