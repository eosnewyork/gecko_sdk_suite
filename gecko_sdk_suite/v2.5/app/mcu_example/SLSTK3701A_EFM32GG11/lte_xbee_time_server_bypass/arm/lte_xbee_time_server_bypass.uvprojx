# Keil uVision project lte_xbee_time_server_bypass.uvprojx, settings and files
target lte_xbee_time_server_bypass (ARM-ADS)
  device: EFM32GG11B820F2048GL192 Silicon Labs
  cpu: IRAM(0x20000000-0x2007FFFF) IROM(0-0x1FFFFF) CLOCK(38400000) CPUTYPE("Cortex-M4") FPU2
  output: lte_xbee_time_server_bypass
  AfterMake: fromelf.exe --bin --output obj\lte_xbee_time_server_bypass.bin obj\lte_xbee_time_server_bypass.axf
  c flags: Optim=4 oTime=1 uC99=1 wLevel=2
  c define: EFM32GG11B820F2048GL192 DEBUG_EFM XBEE_CELLULAR_ENABLED=1 XBEE_DEVICE_ENABLE_ATMODE=1 XBEE_DEMO_CONFIG XBEE_DEMO_HOLOGRAM_SIM XBEE_CHANGE_APN
  c misc: -DXBEE_PLATFORM_HEADER='"xbee/platform_efm32.h"' -DXBEE_TARGET_APN='"hologram"'
  c include: ..\;..\..\..\..\..\platform\CMSIS\Include;..\..\..\..\..\platform\Device\SiliconLabs\EFM32GG11B\Include;..\..\..\..\..\platform\emlib\inc;..\..\..\..\..\hardware\kit\common\drivers;..\..\..\..\..\hardware\kit\common\bsp;..\..\..\..\..\hardware\kit\SLSTK3701A_EFM32GG11\config;..;..\..\..\..\..\platform\middleware\glib;..\..\..\..\..\util\third_party\digi_lte\xbee\inc;..\..\..\..\..\util\third_party\digi_lte\xbee\src\efm32;..\..\..\..\..\util\third_party\digi_lte\xbee\config\inc
  asm define: as above
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFM32GG11B/Source/ARM/: startup_efm32gg11b.s
    ../../../../../platform/Device/SiliconLabs/EFM32GG11B/Source/: system_efm32gg11b.c
  group Drivers
    ../../../../../hardware/kit/common/drivers/: retargetio.c retargettextdisplay.c textdisplay.c display.c displayls013b7dh06.c displaypalemlib.c udelay.c
  group emlib
    ../../../../../platform/emlib/src/: em_assert.c em_cmu.c em_core.c em_emu.c em_gpio.c em_prs.c em_rtcc.c em_system.c em_usart.c
  group Source
    ../: main.c readme.txt
  group XBee
    ../../../../../util/third_party/digi_lte/xbee/src/xbee/: xbee_atmode.c xbee_cbuf.c xbee_device.c
    ../../../../../util/third_party/digi_lte/xbee/src/efm32/: xbee_platform_efm32.c xbee_serial_efm32.c
    ../../../../../util/third_party/digi_lte/xbee/src/util/: hexdump.c hexstrtobyte.c jslong.c memcheck.c swapbytes.c swapcpy.c xmodem_crc16.c
    ../../../../../util/third_party/digi_lte/xbee/src/wpan/: wpan_types.c
    ../../../../../util/third_party/digi_lte/xbee/config/src/: xbee_config.c
