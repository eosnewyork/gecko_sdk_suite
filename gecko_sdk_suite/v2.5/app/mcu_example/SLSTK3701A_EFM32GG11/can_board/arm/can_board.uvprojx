# Keil uVision project can_board.uvprojx, settings and files
target can_board (ARM-ADS)
  device: EFM32GG11B820F2048GL192 Silicon Labs
  cpu: IRAM(0x20000000-0x2007FFFF) IROM(0-0x1FFFFF) CLOCK(38400000) CPUTYPE("Cortex-M4") FPU2
  output: can_board
  AfterMake: fromelf.exe --bin --output obj\can_board.bin obj\can_board.axf
  c flags: Optim=1 oTime=1 uC99=1 wLevel=2
  c define: EFM32GG11B820F2048GL192 DEBUG_EFM RETARGET_VCOM
  c include: ..\;..\..\..\..\..\platform\CMSIS\Include;..\..\..\..\..\platform\Device\SiliconLabs\EFM32GG11B\Include;..\..\..\..\..\platform\emlib\inc;..\..\..\..\..\hardware\kit\common\drivers;..\..\..\..\..\hardware\kit\common\bsp;..\..\..\..\..\hardware\kit\SLSTK3701A_EFM32GG11\config;..\..\..\..\..\platform\middleware\glib;..\..\..\..\..\platform\middleware\glib\glib;..\..\..\..\..\platform\middleware\glib\dmd;..
  asm define: EFM32GG11B820F2048GL192 DEBUG_EFM RETARGET_VCOM
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFM32GG11B/Source/ARM/: startup_efm32gg11b.s
    ../../../../../platform/Device/SiliconLabs/EFM32GG11B/Source/: system_efm32gg11b.c
  group drivers
    ../../../../../hardware/kit/common/drivers/: display.c displayls013b7dh06.c displaypalemlib.c displayconfigapp.h udelay.c
  group glib
    ../../../../../platform/middleware/glib/dmd/display/: dmd_display.c
    ../../../../../platform/middleware/glib/glib/: glib.c glib_line.c glib_string.c glib_rectangle.c glib_font_normal_8x8.c glib_font_narrow_6x8.c glib_font_number_16x20.c
  group bsp
    ../../../../../hardware/kit/common/bsp/: bsp_bcc.c bsp_stk.c bsp_stk_leds.c bsp_trace.c
  group emlib
    ../../../../../platform/emlib/src/: em_assert.c em_cmu.c em_rtcc.c em_emu.c em_gpio.c em_prs.c em_system.c em_usart.c em_core.c em_can.c
  group Source
    ../: can_demo.c
