# Keil uVision project spectrum_analyzer.uvprojx, settings and files
target spectrum_analyzer (ARM-ADS)
  device: EFM32GG11B820F2048GL192 Silicon Labs
  cpu: IRAM(0x20000000-0x2007FFFF) IROM(0-0x1FFFFF) CLOCK(38400000) CPUTYPE("Cortex-M4") FPU2
  output: spectrum_analyzer
  AfterMake: fromelf.exe --bin --output obj\spectrum_analyzer.bin obj\spectrum_analyzer.axf
  c flags: Optim=1 oTime=1 uC99=1 wLevel=2
  c define: EFM32GG11B820F2048GL192 RETARGET_VCOM ARM_MATH_CM4 __FPU_PRESENT=1
  c misc: --diag_suppress=47
  c include: ..\;..\..\..\..\..\platform\CMSIS\Include;..\..\..\..\..\platform\Device\SiliconLabs\EFM32GG11B\Include;..\..\..\..\..\platform\emlib\inc;..\..\..\..\..\hardware\kit\common\drivers;..\..\..\..\..\platform\middleware\glib;..\..\..\..\..\platform\middleware\glib\glib;..\..\..\..\..\platform\middleware\glib\dmd;..\..\..\..\..\hardware\kit\common\bsp;..\..\..\..\..\hardware\kit\SLSTK3701A_EFM32GG11\config;..
  asm define: as above
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFM32GG11B/Source/ARM/: startup_efm32gg11b.s
    ../../../../../platform/Device/SiliconLabs/EFM32GG11B/Source/: system_efm32gg11b.c
  group Drivers
    ../../../../../hardware/kit/common/drivers/: display.c displayls013b7dh06.c displaypalemlib.c udelay.c
  group glib
    ../../../../../platform/middleware/glib/dmd/display/: dmd_display.c
    ../../../../../platform/middleware/glib/glib/: glib.c glib_bitmap.c glib_font_narrow_6x8.c glib_font_normal_8x8.c glib_font_number_16x20.c glib_line.c glib_rectangle.c glib_string.c
  group DSP
    ../../../../../platform/CMSIS/DSP_Lib/Source/ComplexMathFunctions/: arm_cmplx_mag_f32.c
    ../../../../../platform/CMSIS/DSP_Lib/Source/CommonTables/: arm_common_tables.c
    ../../../../../platform/CMSIS/DSP_Lib/Source/TransformFunctions/: arm_rfft_f32.c arm_rfft_init_f32.c arm_bitreversal.c arm_cfft_radix4_f32.c arm_cfft_radix4_init_f32.c
    ../../../../../platform/CMSIS/DSP_Lib/Source/StatisticsFunctions/: arm_max_f32.c
  group emlib
    ../../../../../platform/emlib/src/: em_adc.c em_assert.c em_cmu.c em_core.c em_emu.c em_gpio.c em_ldma.c em_rtcc.c em_prs.c em_system.c em_usart.c
  group Source
    ../: main.c dsp.c lcd.c adc_mode.c mic_mode.c readme.txt
