# Keil uVision project emode.uvprojx, settings and files
target emode (ARM-ADS)
  device: EFM32GG11B820F2048GL192 Silicon Labs
  cpu: IRAM(0x20000000-0x2007FFFF) IROM(0-0x1FFFFF) CLOCK(38400000) CPUTYPE("Cortex-M4") FPU2
  output: emode
  AfterMake: fromelf.exe --bin --output obj\emode.bin obj\emode.axf
  c flags: Optim=4 oTime=1 uC99=1 wLevel=2
  c define: EFM32GG11B820F2048GL192 DEBUG_EFM RETARGET_VCOM ITERATIONS=1000
  c include: ..\;..\..\..\..\..\platform\CMSIS\Include;..\..\..\..\..\platform\Device\SiliconLabs\EFM32GG11B\Include;..\..\..\..\..\platform\emlib\inc;..\..\..\..\..\hardware\kit\common\drivers;..\..\..\..\..\hardware\kit\common\bsp;..\..\..\..\..\hardware\kit\SLSTK3701A_EFM32GG11\config;..\..\..\..\..\platform\middleware\glib;..
  asm define: as above
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFM32GG11B/Source/ARM/: startup_efm32gg11b.s
    ../../../../../platform/Device/SiliconLabs/EFM32GG11B/Source/: system_efm32gg11b.c
  group Drivers
    ../../../../../hardware/kit/common/drivers/: retargetio.c display.c displayls013b7dh06.c displaypalemlib.c retargettextdisplay.c textdisplay.c udelay.c
  group emlib
    ../../../../../platform/emlib/src/: em_assert.c em_system.c em_cmu.c em_emu.c em_gpio.c em_core.c em_pcnt.c em_prs.c em_rtcc.c em_cryotimer.c em_timer.c em_usart.c
  group coremark
    ../coremark/: core_list_join.c core_matrix.c core_state.c core_util.c core_main.c core_main.h core_portme.c core_portme.h coremark.h
  group Source
    ../: main.c lcd_setup.c lcd_setup.h emodes.c emodes.h
