# IAR project micriumos_shell.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32GG11B820F2048GL192 SiliconLaboratories EFM32GG11B820F2048GL192
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: EFM32GG11B820F2048GL192; DEBUG_EFM; RETARGET_VCOM
  ICCARM.CCIncludePath2: ..\..\..\..\..\platform\CMSIS\Include; ..\..\..\..\..\platform\Device\SiliconLabs\EFM32GG11B\Include; ..\..\..\..\..\hardware\kit\common\drivers; ..\..\..\..\..\platform\emlib\inc; ..\..\..\..\..\hardware\kit\common\bsp; ..\..\..\..\..\hardware\kit\common\bsp; ..\..\..\..\..\hardware\kit\SLSTK3701A_EFM32GG11\config; ..\..\..\..\..\platform\micrium_os; ..\..\..\..\..\platform\micrium_os\bsp\siliconlabs\generic\include; ..\cfg; ..
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: EFM32GG11B820F2048GL192; DEBUG_EFM; RETARGET_VCOM
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: micriumos_shell.bin
  ILINK.IlinkOutputFile: micriumos_shell.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32GG11B820F2048GL192; DEBUG_EFM; RETARGET_VCOM
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFM32GG11B/Source/IAR/: startup_efm32gg11b.s
    ../../../../../platform/Device/SiliconLabs/EFM32GG11B/Source/: system_efm32gg11b.c
  group bsp
    ../../../../../hardware/kit/common/bsp/: bsp_bcc.c bsp_stk.c bsp_stk_leds.c bsp_trace.c
    ../../../../../platform/micrium_os/bsp/siliconlabs/generic/source/: bsp_cpu.c bsp_os.c
  group drivers
    ../../../../../hardware/kit/common/drivers/: retargetio.c retargetserial.c
  group emlib
    ../../../../../platform/emlib/src/: em_assert.c em_cmu.c em_core.c em_emu.c em_gpio.c em_system.c em_usart.c em_cryotimer.c em_rtcc.c
  group common
    ../../../../../platform/micrium_os/common/source/auth/: auth.c
    ../../../../../platform/micrium_os/common/source/clk/: clk.c clk_cmd.c
    ../../../../../platform/micrium_os/common/source/collections/: bitmap.c map.c slist.c
    ../../../../../platform/micrium_os/common/source/common/: common.c
    ../../../../../platform/micrium_os/common/source/kal/: kal_kernel.c
    ../../../../../platform/micrium_os/common/source/lib/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../../../../../platform/micrium_os/common/source/rtos/: rtos_err_str.c
    ../../../../../platform/micrium_os/common/source/platform_mgr/: platform_mgr.c
    ../../../../../platform/micrium_os/common/source/shell/: shell.c shell_cmd.c
  group cpu
    ../../../../../platform/micrium_os/cpu/source/: cpu_core.c
    ../../../../../platform/micrium_os/ports/source/iar/: armv7m_cpu_a.asm
    ../../../../../platform/micrium_os/ports/source/generic/: armv6m_v7m_cpu_int.c
  group kernel
    ../../../../../platform/micrium_os/kernel/source/: os_core.c os_cfg_app.c os_dbg.c os_flag.c os_mem.c os_mon.c os_msg.c os_mutex.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
    ../../../../../platform/micrium_os/ports/source/iar/: armv7m_os_cpu_a.asm armv7m_os_cpu_c.c
  group Source
    ../: cmd_help.c cmd_init.c cmd_selftest.c cmd_sleep.c common_init.c main.c shell_util.c cmd_declarations.h shell_util.h
