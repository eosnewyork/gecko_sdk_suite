# Keil uVision project blink.uvprojx, settings and files
target blink (ARM-ADS)
  device: EZR32HG320F64R68 Silicon Labs
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0x7FFF) CLOCK(24000000) CPUTYPE("Cortex-M0+") ESEL ELITTLE
  output: blink
  AfterMake: fromelf.exe --bin --output obj\blink.bin obj\blink.axf
  c flags: Optim=1
  c define: EZR32HG320F64R68 DEBUG_EFM
  c misc: --c99
  c include: ..\;..\..\..\..\..\platform\CMSIS\Include;..\..\..\..\..\platform\Device\SiliconLabs\EZR32HG\Include;..\..\..\..\..\platform\emlib\inc;..\..\..\..\..\hardware\kit\common\bsp;..\..\..\..\..\hardware\kit\SLWSTK6240A_EZR32HG\config
  asm define: EZR32HG320F64R68 DEBUG_EFM
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EZR32HG/Source/ARM/: startup_ezr32hg.s
    ../../../../../platform/Device/SiliconLabs/EZR32HG/Source/: system_ezr32hg.c
  group bsp
    ../../../../../hardware/kit/common/bsp/: bsp_stk_leds.c
  group emlib
    ../../../../../platform/emlib/src/: em_assert.c em_cmu.c em_emu.c em_core.c em_gpio.c
  group Source
    ../: blink.c
