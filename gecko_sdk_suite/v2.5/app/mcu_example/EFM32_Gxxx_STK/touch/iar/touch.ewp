# IAR project touch.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: EFM32G890F128 SiliconLaboratories EFM32G890F128
  ICCARM.CCDefines: EFM32G890F128
  ICCARM.CCIncludePath2: ..\..\..\..\..\platform\CMSIS\Include; ..\..\..\..\..\platform\Device\SiliconLabs\EFM32G\Include; ..\..\..\..\..\platform\emlib\inc; ..\..\..\..\..\hardware\kit\common\drivers; ..\..\..\..\..\hardware\kit\common\bsp; ..\..\..\..\..\hardware\kit\EFM32_Gxxx_STK\config; ..\..\..\..\..\platform\emdrv\common\inc; ..\..\..\..\..\platform\emdrv\rtcdrv\inc; ..
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.ADefines: EFM32G890F128
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: touch.bin
  ILINK.IlinkOutputFile: touch.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32G890F128
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFM32G/Source/IAR/: startup_efm32g.s
    ../../../../../platform/Device/SiliconLabs/EFM32G/Source/: system_efm32g.c
  group BSP
    ../../../../../hardware/kit/common/bsp/: bsp_bcc.c bsp_stk.c bsp_trace.c
  group Drivers
    ../../../../../hardware/kit/common/drivers/: vddcheck.c segmentlcd.c capsense.c
  group emlib
    ../../../../../platform/emlib/src/: em_assert.c em_acmp.c em_cmu.c em_core.c em_emu.c em_gpio.c em_rtc.c em_system.c em_lcd.c em_usart.c em_vcmp.c
  group emdrv
    ../../../../../platform/emdrv/rtcdrv/src/: rtcdriver.c
  group Source
    ../: touchdemo.c
