# IAR project webserver.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: EFM32GG990F1024 SiliconLaboratories EFM32GG990F1024
  ICCARM.CCDefines: EFM32GG990F1024; DEBUG_EFM; __HEAP_SIZE=128
  ICCARM.CCDiagSuppress: Pa050,Pe550
  ICCARM.CCIncludePath2: ..; ..\..\..\..\..\platform\CMSIS\Include; ..\..\..\..\..\platform\Device\SiliconLabs\EFM32GG\Include; ..\..\..\..\..\platform\emlib\inc; ..\..\..\..\..\platform\emdrv\common\inc; ..\..\..\..\..\platform\emdrv\spidrv\inc; ..\..\..\..\..\platform\emdrv\spidrv\config; ..\..\..\..\..\platform\emdrv\rtcdrv\inc; ..\..\..\..\..\platform\emdrv\rtcdrv\config; ..\..\..\..\..\platform\emdrv\dmadrv\inc; ..\..\..\..\..\platform\emdrv\dmadrv\config; ..\..\..\..\..\hardware\kit\common\drivers; ..\..\..\..\..\hardware\kit\common\bsp; ..\..\..\..\..\hardware\kit\EFM32GG_DK3750\config; ..\..\..\..\..\platform\middleware\glib; ..\..\..\..\..\platform\middleware\glib\glib; ..\..\..\..\..\util\third_party\lwip\lwip\src\; ..\..\..\..\..\util\third_party\lwip\lwip\src\api; ..\..\..\..\..\util\third_party\lwip\lwip\src\core; ..\..\..\..\..\util\third_party\lwip\lwip\src\core\ipv4; ..\..\..\..\..\util\third_party\lwip\lwip\src\include; ..\..\..\..\..\util\third_party\lwip\lwip\src\include\ipv4; ..\..\..\..\..\util\third_party\lwip\lwip\src\include\ipv4\lwip; ..\..\..\..\..\util\third_party\lwip\lwip\src\include\lwip; ..\..\..\..\..\util\third_party\lwip\lwip-contrib\apps\ping; ..\..\..\..\..\util\third_party\lwip\lwip-contrib\apps\tcpecho_raw; ..\..\..\..\..\util\third_party\lwip\lwip-contrib\apps\httpserver_raw; ..\..\..\..\..\util\third_party\lwip\lwip-contrib\ports\EFM32\; ..\..\..\..\..\util\third_party\lwip\lwip-contrib\ports\EFM32\include\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.ADefines: EFM32GG990F1024; DEBUG_EFM; __HEAP_SIZE=128
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: webserver.bin
  ILINK.IlinkOutputFile: webserver.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32GG990F1024; DEBUG_EFM; __HEAP_SIZE=128
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFM32GG/Source/IAR/: startup_efm32gg.s
    ../../../../../platform/Device/SiliconLabs/EFM32GG/Source/: system_efm32gg.c
  group emlib
    ../../../../../platform/emlib/src/: em_assert.c em_system.c em_cmu.c em_core.c em_emu.c em_gpio.c em_ebi.c em_usart.c em_rtc.c em_dma.c
  group emdrv
    ../../../../../platform/emdrv/spidrv/src/: spidrv.c
    ../../../../../platform/emdrv/rtcdrv/src/: rtcdriver.c
    ../../../../../platform/emdrv/dmadrv/src/: dmadrv.c
  group BSP
    ../../../../../hardware/kit/common/bsp/: bsp_dk_3201.c bsp_trace.c bsp_dk_leds.c
  group Drivers
    ../../../../../hardware/kit/common/drivers/: ksz8851snl.c ksz8851snl_spi.c retargetserial.c retargetio.c dmactrl.c
    ../: tftconsole.c
  group Graphics
    ../../../../../platform/middleware/glib/dmd/ssd2119/: dmd_ssd2119_16bit.c dmdif_ssd2119_ebi16.c
  group lwip
    ../../../../../util/third_party/lwip/lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../../../util/third_party/lwip/lwip/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../../../../util/third_party/lwip/lwip/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../../../../../util/third_party/lwip/lwip/src/netif/: etharp.c ethernetif.c
  group lwip-contrib
    ../../../../../util/third_party/lwip/lwip-contrib/apps/tcpecho_raw/: echo.c
    ../../../../../util/third_party/lwip/lwip-contrib/apps/httpserver_raw/: fs.c httpd.c
    ../../../../../util/third_party/lwip/lwip-contrib/ports/efm32/: ksz8851snl_driver.c
  group Source
    ../: webserver.c
