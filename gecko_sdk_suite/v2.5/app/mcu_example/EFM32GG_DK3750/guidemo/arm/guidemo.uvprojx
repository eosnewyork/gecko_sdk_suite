# Keil uVision project guidemo.uvprojx, settings and files
target guidemo (ARM-ADS)
  device: EFM32GG990F1024 Silicon Labs
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0-0xFFFFF) CLOCK(48000000) CPUTYPE("Cortex-M3")
  output: guidemo
  AfterMake: fromelf.exe --bin --output obj\guidemo.bin obj\guidemo.axf
  c flags: Optim=4
  c define: EFM32GG990F1024 DEBUG_EFM ENERGY_AWARE
  c misc: --c99
  c include: ..\;..\..\..\..\..\platform\CMSIS\Include;..\..\..\..\..\platform\Device\SiliconLabs\EFM32GG\Include;..\..\..\..\..\platform\emlib\inc;..\..\..\..\..\util\third_party\emwin\inc;..\..\..\..\..\platform\middleware\glib;..\..\..\..\..\hardware\kit\common\drivers\emwin\Dk3750;..\..\..\..\..\hardware\kit\common\drivers;..\..\..\..\..\hardware\kit\common\bsp;..\..\..\..\..\hardware\kit\EFM32GG_DK3750\config;..
  asm define: EFM32GG990F1024 DEBUG_EFM ENERGY_AWARE
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group CMSIS
    ../: startup_arm.s
    ../../../../../platform/Device/SiliconLabs/EFM32GG/Source/: system_efm32gg.c
  group emlib
    ../../../../../platform/emlib/src/: em_assert.c em_adc.c em_cmu.c em_core.c em_emu.c em_system.c em_rtc.c em_wdog.c em_gpio.c em_ebi.c em_usart.c em_i2c.c
  group bsp
    ../../../../../hardware/kit/common/bsp/: bsp_dk_3201.c bsp_trace.c
  group Drivers
    ../../../../../hardware/kit/common/drivers/: calibrate.c eeprom.c i2cspm.c tftspi.c touch.c tftdirect.c
    ../../../../../platform/middleware/glib/dmd/ssd2119/: dmd_ssd2119_direct.c
  group emwin
    ../: GUIConf.c
    ../../../../../hardware/kit/common/drivers/emwin/Dk3750/: LCDConf.c GUI_X.c
  group Source
    ../: GUIDEMO.c GUIDEMO_Automotive.c GUIDEMO_BarGraph.c GUIDEMO_Bitmap.c GUIDEMO_ColorBar.c GUIDEMO_Conf.c GUIDEMO_Cursor.c GUIDEMO_Fading.c GUIDEMO_Graph.c GUIDEMO_IconView.c GUIDEMO_ImageFlow.c GUIDEMO_Intro.c GUIDEMO_Listview.c GUIDEMO_Resource.c GUIDEMO_Skinning.c GUIDEMO_Speed.c GUIDEMO_Speedometer.c GUIDEMO_Start.c GUIDEMO_TransparentDialog.c GUIDEMO_Treeview.c GUIDEMO_VScreen.c GUIDEMO_WashingMachine.c GUIDEMO_ZoomAndRotate.c
  group Libraries
    ../../../../../util/third_party/emwin/lib/: emwin_ARM_CM3.lib
