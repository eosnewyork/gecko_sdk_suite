# Keil uVision project slideshow.uvprojx, settings and files
target slideshow (ARM-ADS)
  device: EFM32GG990F1024 Silicon Labs
  pack: SiliconLabs.EFM32GG_DFP.5.5.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0-0xFFFFF) CLOCK(48000000) CPUTYPE("Cortex-M3")
  output: slideshow
  AfterMake: fromelf.exe --bin --output obj\slideshow.bin obj\slideshow.axf
  c flags: Optim=4 oTime=1 v6Lang=1 v6LangP=1
  c define: EFM32GG990F1024 DEBUG_EFM
  c misc: --c99
  c include: ..\;..\..\..\..\..\platform\CMSIS\Include;..\..\..\..\..\platform\Device\SiliconLabs\EFM32GG\Include;..\..\..\..\..\platform\emlib\inc;..\..\..\..\..\hardware\kit\common\drivers;..\..\..\..\..\hardware\kit\common\bsp;..\..\..\..\..\hardware\kit\EFM32GG_DK3750\config;..\..\..\..\..\util\third_party\fatfs\inc;..;..\..\..\..\..\platform\middleware\glib
  asm define: EFM32GG990F1024 DEBUG_EFM
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFM32GG/Source/ARM/: startup_efm32gg.s
    ../../../../../platform/Device/SiliconLabs/EFM32GG/Source/: system_efm32gg.c
  group emlib
    ../../../../../platform/emlib/src/: em_assert.c em_cmu.c em_core.c em_dbg.c em_msc.c em_ebi.c em_emu.c em_gpio.c em_rtc.c em_rmu.c em_system.c em_usart.c em_wdog.c
  group bsp
    ../../../../../hardware/kit/common/bsp/: bsp_dk_3201.c bsp_trace.c
  group Drivers
    ../../../../../hardware/kit/common/drivers/: tftamapped.c microsd.c
  group glib
    ../../../../../platform/middleware/glib/glib/: bmp.c glib.c glib_bitmap.c glib_circle.c glib_line.c glib_polygon.c glib_rectangle.c glib_string.c glib_font_normal_8x8.c
    ../../../../../platform/middleware/glib/dmd/ssd2119/: dmd_ssd2119_16bit.c dmdif_ssd2119_ebi16.c
  group FatFS
    ../../../../../util/third_party/fatfs/src/: diskio.c ff.c
  group Source
    ../: slideshow.c slides.c
