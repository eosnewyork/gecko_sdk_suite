# IAR project usbdmsd.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: EFM32GG990F1024 SiliconLaboratories EFM32GG990F1024
  ICCARM.CCDefines: EFM32GG990F1024; DEBUG_EFM_USER
  ICCARM.CCIncludePath2: ..; ..\..\..\..\..\platform\CMSIS\Include; ..\..\..\..\..\platform\Device\SiliconLabs\EFM32GG\Include; ..\..\..\..\..\platform\emlib\inc; ..\..\..\..\..\platform\middleware\usb_gecko\inc; ..\..\..\..\..\util\third_party\fatfs\inc; ..\..\..\..\..\hardware\kit\common\drivers; ..\..\..\..\..\hardware\kit\common\bsp; ..\..\..\..\..\hardware\kit\EFM32GG_DK3750\config
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.ADefines: EFM32GG990F1024; DEBUG_EFM_USER
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: usbdmsd.bin
  ILINK.IlinkOutputFile: usbdmsd.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32GG990F1024; DEBUG_EFM_USER
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFM32GG/Source/IAR/: startup_efm32gg.s
    ../../../../../platform/Device/SiliconLabs/EFM32GG/Source/: system_efm32gg.c
  group bsp
    ../../../../../hardware/kit/common/bsp/: bsp_dk_3201.c bsp_trace.c
  group drivers
    ../../../../../hardware/kit/common/drivers/: norflash.c msdd.c retargetio.c retargetserial.c microsd.c
  group FatFS
    ../../../../../util/third_party/fatfs/src/: diskio.c
  group emlib
    ../../../../../platform/emlib/src/: em_assert.c em_cmu.c em_core.c em_ebi.c em_emu.c em_gpio.c em_msc.c em_system.c em_timer.c em_usart.c
  group emusb
    ../../../../../platform/middleware/usb_gecko/src/: em_usbd.c em_usbdch9.c em_usbhal.c em_usbdep.c em_usbdint.c em_usbtimer.c
  group Source
    ../: main.c msddmedia.c descriptors.c
