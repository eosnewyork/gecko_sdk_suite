# IAR project freertos_blink.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: EFM32GG990F1024 SiliconLaboratories EFM32GG990F1024
  ICCARM.CCDefines: EFM32GG990F1024; IAR_ARM_CM3; DEBUG_EFM
  ICCARM.CCIncludePath2: ..\..\..\..\..\platform\CMSIS\Include; ..\..\..\..\..\platform\Device\SiliconLabs\EFM32GG\Include; ..\..\..\..\..\platform\emlib\inc; ..\..\..\..\..\platform\emdrv\sleep\inc; ..\..\..\..\..\hardware\kit\common\bsp; ..; ..\..\..\..\..\util\third_party\freertos\Source\include; ..\..\..\..\..\util\third_party\freertos\Source\portable\IAR\ARM_CM3; ..\..\..\..\..\hardware\kit\EFM32GG_DK3750\config
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.ADefines: EFM32GG990F1024; IAR_ARM_CM3; DEBUG_EFM
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: freertos_blink.bin
  ILINK.IlinkOutputFile: freertos_blink.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32GG990F1024; IAR_ARM_CM3; DEBUG_EFM
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFM32GG/Source/IAR/: startup_efm32gg.s
    ../../../../../platform/Device/SiliconLabs/EFM32GG/Source/: system_efm32gg.c
  group BSP
    ../../../../../hardware/kit/common/bsp/: bsp_dk_3201.c bsp_dk_leds.c bsp_trace.c
  group emlib
    ../../../../../platform/emlib/src/: em_assert.c em_burtc.c em_cmu.c em_core.c em_emu.c em_gpio.c em_rmu.c em_rtc.c em_ebi.c em_usart.c em_system.c
  group emdrv
    ../../../../../platform/emdrv/sleep/src/: sleep.c
  group freertos
    ../../../../../util/third_party/freertos/Source/: timers.c tasks.c queue.c list.c croutine.c event_groups.c
    ../../../../../util/third_party/freertos/Source/portable/MemMang/: heap_1.c
    ../../../../../util/third_party/freertos/Source/portable/IAR/ARM_CM3/: port.c portasm.s
  group Source
    ../: main.c low_power_tick_management.c
