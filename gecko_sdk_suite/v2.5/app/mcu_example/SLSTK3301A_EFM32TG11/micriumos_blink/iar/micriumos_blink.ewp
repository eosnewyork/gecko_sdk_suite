# IAR project micriumos_blink.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: EFM32TG11B520F128GM80 SiliconLaboratories EFM32TG11B520F128GM80
  ICCARM.CCDefines: EFM32TG11B520F128GM80; DEBUG_EFM
  ICCARM.CCIncludePath2: ..\..\..\..\..\platform\CMSIS\Include; ..\..\..\..\..\platform\Device\SiliconLabs\EFM32TG11B\Include; ..\..\..\..\..\platform\emlib\inc; ..\..\..\..\..\hardware\kit\common\bsp; ..\..\..\..\..\hardware\kit\SLSTK3301A_EFM32TG11\config; ..\..\..\..\..\platform\micrium_os; ..\..\..\..\..\platform\micrium_os\bsp\siliconlabs\generic\include; ..\cfg; ..
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.ADefines: EFM32TG11B520F128GM80; DEBUG_EFM
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: micriumos_blink.bin
  ILINK.IlinkOutputFile: micriumos_blink.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32TG11B520F128GM80; DEBUG_EFM
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFM32TG11B/Source/IAR/: startup_efm32tg11b.s
    ../../../../../platform/Device/SiliconLabs/EFM32TG11B/Source/: system_efm32tg11b.c
  group bsp
    ../../../../../hardware/kit/common/bsp/: bsp_bcc.c bsp_stk.c bsp_stk_leds.c bsp_trace.c
    ../../../../../platform/micrium_os/bsp/siliconlabs/generic/source/: bsp_cpu.c bsp_os.c
  group emlib
    ../../../../../platform/emlib/src/: em_assert.c em_cmu.c em_core.c em_ebi.c em_emu.c em_gpio.c em_system.c em_usart.c
  group common
    ../../../../../platform/micrium_os/common/source/auth/: auth.c
    ../../../../../platform/micrium_os/common/source/clk/: clk.c clk_cmd.c
    ../../../../../platform/micrium_os/common/source/collections/: bitmap.c map.c slist.c
    ../../../../../platform/micrium_os/common/source/common/: common.c
    ../../../../../platform/micrium_os/common/source/kal/: kal_kernel.c
    ../../../../../platform/micrium_os/common/source/lib/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../../../../../platform/micrium_os/common/source/rtos/: rtos_err_str.c
    ../../../../../platform/micrium_os/common/source/platform_mgr/: platform_mgr.c
  group cpu
    ../../../../../platform/micrium_os/cpu/source/: cpu_core.c
    ../../../../../platform/micrium_os/ports/source/iar/: armv6m_cpu_a.asm
    ../../../../../platform/micrium_os/ports/source/generic/: armv6m_v7m_cpu_int.c
  group kernel
    ../../../../../platform/micrium_os/kernel/source/: os_core.c os_cfg_app.c os_dbg.c os_flag.c os_mem.c os_mon.c os_msg.c os_mutex.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
    ../../../../../platform/micrium_os/ports/source/iar/: armv6m_os_cpu_a.asm armv6m_os_cpu_c.c
  group Source
    ../: ex_main.c
