# Keil uVision project cslib.uvprojx, settings and files
target cslib (ARM-ADS)
  device: EFM32TG11B520F128GM80 Silicon Labs
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x1FFFF) CLOCK(48000000) CPUTYPE("Cortex-M0+") ESEL ELITTLE
  output: cslib
  AfterMake: fromelf.exe --bin --output obj\cslib.bin obj\cslib.axf
  c flags: Optim=1 oTime=1 uC99=1 wLevel=2
  c define: EFM32TG11B520F128GM80 DEBUG_EFM RETARGET_VCOM
  c include: ..\;..\..\..\..\..\platform\CMSIS\Include;..\..\..\..\..\platform\Device\SiliconLabs\EFM32TG11B\Include;..\..\..\..\..\platform\emlib\inc;..\..\..\..\..\hardware\kit\common\bsp;..\..\..\..\..\hardware\kit\SLSTK3301A_EFM32TG11\config;..\..\..\..\..\platform\middleware\cslib\inc;..\..\..\..\..\platform\middleware\cslib\src\app;..\..\..\..\..\platform\middleware\cslib\src\device_CSEN;..\..\..\..\..\platform\middleware\cslib\src\serial;..\..\..\..\..\platform\middleware\cslib\src\config_CSEN;..\..\..\..\..\platform\emdrv\rtcdrv\inc;..\..\..\..\..\platform\emdrv\rtcdrv\config;..\..\..\..\..\platform\emdrv\common\inc;..\..\..\..\..\hardware\kit\common\drivers;..
  asm define: EFM32TG11B520F128GM80 DEBUG_EFM RETARGET_VCOM
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFM32TG11B/Source/ARM/: startup_efm32tg11b.s
    ../../../../../platform/Device/SiliconLabs/EFM32TG11B/Source/: system_efm32tg11b.c
  group bsp
    ../../../../../hardware/kit/common/bsp/: bsp_bcc.c bsp_stk.c bsp_stk_leds.c bsp_trace.c
  group drivers
    ../../../../../hardware/kit/common/drivers/: retargetserial.c retargetio.c
  group emlib
    ../../../../../platform/emlib/src/: em_acmp.c em_assert.c em_cmu.c em_ebi.c em_emu.c em_gpio.c em_core.c em_ldma.c em_csen.c em_system.c em_vcmp.c em_leuart.c em_usart.c
  group app
    ../../../../../platform/middleware/cslib/src/app/: cslib_config.c device_init.c
  group device_CSEN
    ../../../../../platform/middleware/cslib/src/device_CSEN/: hardware_config.c hardware_routines.c low_power_config.c
  group serial
    ../../../../../platform/middleware/cslib/src/serial/: comm_routines.c profiler_interface.c sensor_descriptors.c
  group Source
    ../: main.c cslib_hwconfig.h
  group Libraries
    ../../../../../platform/middleware/cslib/lib/: libCSLIB_M0_CSEN_arm.lib
