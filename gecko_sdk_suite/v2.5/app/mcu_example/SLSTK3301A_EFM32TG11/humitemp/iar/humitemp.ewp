# IAR project humitemp.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: EFM32TG11B520F128GM80 SiliconLaboratories EFM32TG11B520F128GM80
  ICCARM.CCDefines: EFM32TG11B520F128GM80
  ICCARM.CCIncludePath2: ..\..\..\..\..\platform\CMSIS\Include; ..\..\..\..\..\platform\Device\SiliconLabs\EFM32TG11B\Include; ..\..\..\..\..\platform\emlib\inc; ..\..\..\..\..\platform\emdrv\common\inc; ..\..\..\..\..\platform\emdrv\rtcdrv\inc; ..\..\..\..\..\platform\emdrv\rtcdrv\config; ..\..\..\..\..\hardware\kit\common\drivers; ..\..\..\..\..\hardware\kit\common\bsp; ..\..\..\..\..\hardware\kit\SLSTK3301A_EFM32TG11\config; ..
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.ADefines: EFM32TG11B520F128GM80
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: humitemp.bin
  ILINK.IlinkOutputFile: humitemp.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32TG11B520F128GM80
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFM32TG11B/Source/IAR/: startup_efm32tg11b.s
    ../../../../../platform/Device/SiliconLabs/EFM32TG11B/Source/: system_efm32tg11b.c
  group bsp
    ../../../../../hardware/kit/common/bsp/: bsp_bcc.c bsp_stk.c
  group emdrv
    ../../../../../platform/emdrv/rtcdrv/src/: rtcdriver.c
  group Drivers
    ../../../../../hardware/kit/common/drivers/: segmentlcd.c si7013.c i2cspm.c
  group emlib
    ../../../../../platform/emlib/src/: em_assert.c em_system.c em_cmu.c em_core.c em_emu.c em_gpio.c em_lcd.c em_rtcc.c em_i2c.c em_usart.c
  group Source
    ../: humitemp.c
