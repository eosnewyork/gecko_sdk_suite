# Keil uVision project humitemp.uvprojx, settings and files
target humitemp (ARM-ADS)
  device: EFM32TG11B520F128GM80 Silicon Labs
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x1FFFF) CLOCK(48000000) CPUTYPE("Cortex-M0+") ESEL ELITTLE
  output: humitemp
  AfterMake: fromelf.exe --bin --output obj\humitemp.bin obj\humitemp.axf
  c flags: Optim=4 uC99=1 wLevel=2
  c define: EFM32TG11B520F128GM80
  c include: ..\;..\..\..\..\..\platform\CMSIS\Include;..\..\..\..\..\platform\Device\SiliconLabs\EFM32TG11B\Include;..\..\..\..\..\platform\emlib\inc;..\..\..\..\..\platform\emdrv\common\inc;..\..\..\..\..\platform\emdrv\rtcdrv\inc;..\..\..\..\..\platform\emdrv\rtcdrv\config;..\..\..\..\..\hardware\kit\common\drivers;..\..\..\..\..\hardware\kit\common\bsp;..\..\..\..\..\hardware\kit\SLSTK3301A_EFM32TG11\config;..
  asm define: EFM32TG11B520F128GM80
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFM32TG11B/Source/ARM/: startup_efm32tg11b.s
    ../../../../../platform/Device/SiliconLabs/EFM32TG11B/Source/: system_efm32tg11b.c
  group bsp
    ../../../../../hardware/kit/common/bsp/: bsp_bcc.c bsp_stk.c
  group emdrv
    ../../../../../platform/emdrv/rtcdrv/src/: rtcdriver.c
  group Drivers
    ../../../../../hardware/kit/common/drivers/: segmentlcd.c si7013.c i2cspm.c
  group emlib
    ../../../../../platform/emlib/src/: em_assert.c em_system.c em_cmu.c em_core.c em_emu.c em_gpio.c em_lcd.c em_rtcc.c em_i2c.c em_usart.c
  group Source
    ../: humitemp.c
