# Keil uVision project lcd.uvprojx, settings and files
target lcd (ARM-ADS)
  device: EFM32TG11B520F128GM80 Silicon Labs
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x1FFFF) CLOCK(48000000) CPUTYPE("Cortex-M0+") ESEL ELITTLE
  output: lcd
  AfterMake: fromelf.exe --bin --output obj\lcd.bin obj\lcd.axf
  c flags: Optim=4 oTime=1 uC99=1 wLevel=2
  c define: EFM32TG11B520F128GM80 DEBUG_EFM
  c include: ..\;..\..\..\..\..\platform\CMSIS\Include;..\..\..\..\..\platform\Device\SiliconLabs\EFM32TG11B\Include;..\..\..\..\..\platform\emlib\inc;..\..\..\..\..\platform\emdrv\gpiointerrupt\inc;..\..\..\..\..\platform\emdrv\rtcdrv\inc;..\..\..\..\..\platform\emdrv\rtcdrv\config;..\..\..\..\..\platform\emdrv\common\inc;..\..\..\..\..\hardware\kit\common\drivers;..\..\..\..\..\hardware\kit\common\bsp;..\..\..\..\..\hardware\kit\SLSTK3301A_EFM32TG11\config
  asm define: EFM32TG11B520F128GM80 DEBUG_EFM
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFM32TG11B/Source/ARM/: startup_efm32tg11b.s
    ../../../../../platform/Device/SiliconLabs/EFM32TG11B/Source/: system_efm32tg11b.c
  group Drivers
    ../../../../../hardware/kit/common/drivers/: segmentlcd.c
  group emdrv
    ../../../../../platform/emdrv/gpiointerrupt/src/: gpiointerrupt.c
    ../../../../../platform/emdrv/rtcdrv/src/: rtcdriver.c
  group emlib
    ../../../../../platform/emlib/src/: em_assert.c em_cmu.c em_emu.c em_gpio.c em_lcd.c em_core.c em_rtcc.c
  group Source
    ../: lcd.c
