# Keil uVision project helges_demo.uvprojx, settings and files
target helges_demo (ARM-ADS)
  device: EFM32TG11B520F128GM80 Silicon Labs
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x1FFFF) CLOCK(48000000) CPUTYPE("Cortex-M0+") ESEL ELITTLE
  output: helges_demo
  AfterMake: fromelf.exe --bin --output obj\helges_demo.bin obj\helges_demo.axf
  c flags: Optim=1 oTime=1 uC99=1 wLevel=2
  c define: EFM32TG11B520F128GM80 DEBUG_EFM
  c include: ..\;..\..\..\..\..\platform\CMSIS\Include;..\..\..\..\..\platform\Device\SiliconLabs\EFM32TG11B\Include;..\..\..\..\..\platform\emlib\inc;..\..\..\..\..\hardware\kit\common\drivers;..\..\..\..\..\hardware\kit\common\bsp;..\..\..\..\..\hardware\kit\SLSTK3301A_EFM32TG11\config;..
  asm define: EFM32TG11B520F128GM80 DEBUG_EFM
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group bsp
    ../../../../../hardware/kit/common/bsp/: bsp_stk_leds.c
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFM32TG11B/Source/ARM/: startup_efm32tg11b.s
    ../../../../../platform/Device/SiliconLabs/EFM32TG11B/Source/: system_efm32tg11b.c
  group Drivers
    ../../../../../hardware/kit/common/drivers/: i2cspm.c segmentlcd.c si7013.c si72xx.c
  group emlib
    ../../../../../platform/emlib/src/: em_acmp.c em_adc.c em_assert.c em_cmu.c em_core.c em_cryotimer.c em_csen.c em_emu.c em_gpio.c em_i2c.c em_lcd.c em_lesense.c em_rmu.c em_rtcc.c em_system.c em_vdac.c
  group Source
    ../: app_bumode.c app_csen.c app_rtcc.c app_sensor.c main.c
