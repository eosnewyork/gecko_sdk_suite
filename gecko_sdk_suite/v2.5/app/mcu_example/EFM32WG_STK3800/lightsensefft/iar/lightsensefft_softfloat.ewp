# IAR project lightsensefft_softfloat.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: EFM32LG990F256 SiliconLaboratories EFM32LG990F256
  ICCARM.CCDefines: EFM32LG990F256; ARM_MATH_CM3
  ICCARM.CCIncludePath2: ..\..\..\..\..\platform\CMSIS\Include; ..\..\..\..\..\platform\Device\SiliconLabs\EFM32LG\Include; ..\..\..\..\..\platform\emlib\inc; ..\..\..\..\..\hardware\kit\common\drivers; ..\..\..\..\..\hardware\kit\common\bsp; ..\..\..\..\..\hardware\kit\EFM32WG_STK3800\config
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.ADefines: EFM32LG990F256; ARM_MATH_CM3
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: lightsensefft_softfloat.bin
  ILINK.IlinkOutputFile: lightsensefft_softfloat.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32LG990F256; ARM_MATH_CM3
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  group BSP
    ../../../../../hardware/kit/common/bsp/: bsp_bcc.c bsp_stk.c bsp_trace.c
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFM32LG/Source/IAR/: startup_efm32lg.s
    ../../../../../platform/Device/SiliconLabs/EFM32LG/Source/: system_efm32lg.c
  group Drivers
    ../../../../../hardware/kit/common/drivers/: dmactrl.c segmentlcd.c
  group DSP
    ../../../../../platform/CMSIS/DSP_Lib/Source/TransformFunctions/: arm_bitreversal.c arm_cfft_radix4_f32.c arm_cfft_radix4_init_f32.c arm_rfft_f32.c arm_rfft_init_f32.c
    ../../../../../platform/CMSIS/DSP_Lib/Source/ComplexMathFunctions/: arm_cmplx_mag_f32.c
    ../../../../../platform/CMSIS/DSP_Lib/Source/StatisticsFunctions/: arm_max_f32.c
    ../../../../../platform/CMSIS/DSP_Lib/Source/CommonTables/: arm_common_tables.c
  group emlib
    ../../../../../platform/emlib/src/: em_adc.c em_assert.c em_cmu.c em_core.c em_dma.c em_ebi.c em_emu.c em_gpio.c em_lcd.c em_prs.c em_system.c em_timer.c em_usart.c
  group Source
    ../: lightsensefft.c
