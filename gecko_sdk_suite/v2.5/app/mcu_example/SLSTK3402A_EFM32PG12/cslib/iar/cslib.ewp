# IAR project cslib.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32PG12B500F1024GL125 SiliconLaboratories EFM32PG12B500F1024GL125
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: EFM32PG12B500F1024GL125; DEBUG_EFM; RETARGET_VCOM
  ICCARM.CCIncludePath2: ..\..\..\..\..\platform\CMSIS\Include; ..\..\..\..\..\platform\Device\SiliconLabs\EFM32PG12B\Include; ..\..\..\..\..\platform\emlib\inc; ..\..\..\..\..\hardware\kit\common\bsp; ..\..\..\..\..\hardware\kit\SLSTK3402A_EFM32PG12\config; ..\..\..\..\..\platform\middleware\cslib\inc; ..\..\..\..\..\platform\middleware\cslib\src\app; ..\..\..\..\..\platform\middleware\cslib\src\device_CSEN; ..\..\..\..\..\platform\middleware\cslib\src\serial; ..\..\..\..\..\platform\middleware\cslib\src\config_CSEN; ..\..\..\..\..\platform\emdrv\rtcdrv\inc; ..\..\..\..\..\platform\emdrv\rtcdrv\config; ..\..\..\..\..\platform\emdrv\common\inc; ..\..\..\..\..\hardware\kit\common\drivers; ..
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: EFM32PG12B500F1024GL125; DEBUG_EFM; RETARGET_VCOM
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: cslib.bin
  ILINK.IlinkOutputFile: cslib.out
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\platform\middleware\cslib\lib\libCSLIB_M3_4_CSEN_iar.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32PG12B500F1024GL125; DEBUG_EFM; RETARGET_VCOM
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFM32PG12B/Source/IAR/: startup_efm32pg12b.s
    ../../../../../platform/Device/SiliconLabs/EFM32PG12B/Source/: system_efm32pg12b.c
  group bsp
    ../../../../../hardware/kit/common/bsp/: bsp_bcc.c bsp_stk.c bsp_stk_leds.c bsp_trace.c
  group drivers
    ../../../../../hardware/kit/common/drivers/: retargetserial.c retargetio.c
  group emlib
    ../../../../../platform/emlib/src/: em_acmp.c em_assert.c em_cmu.c em_ebi.c em_emu.c em_gpio.c em_core.c em_ldma.c em_csen.c em_system.c em_vcmp.c em_leuart.c em_usart.c
  group app
    ../../../../../platform/middleware/cslib/src/app/: cslib_config.c device_init.c
  group device_CSEN
    ../../../../../platform/middleware/cslib/src/device_CSEN/: hardware_config.c hardware_routines.c low_power_config.c
  group serial
    ../../../../../platform/middleware/cslib/src/serial/: comm_routines.c profiler_interface.c sensor_descriptors.c
  group Source
    ../: cslib_hwconfig.h main.c
