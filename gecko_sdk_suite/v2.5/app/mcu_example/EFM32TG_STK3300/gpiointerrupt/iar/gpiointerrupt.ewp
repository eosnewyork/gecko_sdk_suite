# IAR project gpiointerrupt.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: EFM32TG840F32 SiliconLaboratories EFM32TG840F32
  ICCARM.CCDefines: EFM32TG840F32; DEBUG_EFM
  ICCARM.CCIncludePath2: ..\..\..\..\..\platform\CMSIS\Include; ..\..\..\..\..\platform\Device\SiliconLabs\EFM32TG\Include; ..\..\..\..\..\platform\emlib\inc; ..\..\..\..\..\platform\emdrv\gpiointerrupt\inc; ..\..\..\..\..\hardware\kit\common\bsp; ..\..\..\..\..\hardware\kit\EFM32TG_STK3300\config
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.ADefines: EFM32TG840F32; DEBUG_EFM
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: gpiointerrupt.bin
  ILINK.IlinkOutputFile: gpiointerrupt.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32TG840F32; DEBUG_EFM
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFM32TG/Source/IAR/: startup_efm32tg.s
    ../../../../../platform/Device/SiliconLabs/EFM32TG/Source/: system_efm32tg.c
  group bsp
    ../../../../../hardware/kit/common/bsp/: bsp_bcc.c bsp_stk.c bsp_stk_leds.c bsp_trace.c
  group emlib
    ../../../../../platform/emlib/src/: em_assert.c em_cmu.c em_core.c em_ebi.c em_emu.c em_gpio.c em_usart.c em_system.c
  group emdrv
    ../../../../../platform/emdrv/gpiointerrupt/src/: gpiointerrupt.c
  group Source
    ../: main.c
