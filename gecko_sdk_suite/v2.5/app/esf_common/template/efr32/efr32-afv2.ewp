# IAR project efr32-afv2.ewp, settings and files
configuration Normal (ARM, debug)
  General.OGChipSelectEditMenu: $--partNumber--$ SiliconLaboratories $--partNumber--$
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: $--bootloader--$; CORTEXM3; CORTEXM3_EFR32; CORTEXM3_EFR32_MICRO; CORTEXM3_EFM32_MICRO; EFR32_SERIES$--partHardware.series--$_CONFIG$--partHardware.device_configuration--$_MICRO; $--chipFamily;U--$; $--partNumber;U--$; ATTRIBUTE_STORAGE_CONFIGURATION="app/builder/$--deviceName--$/$--deviceName--$_endpoint_config.h"; CONFIGURATION_HEADER="app/framework/util/config.h"; GENERATED_TOKEN_HEADER="app/builder/$--deviceName--$/$--tokenHeader--$"; PLATFORM_HEADER="$--halDirFromStackFs--$/micro/cortexm3/compiler/iar.h"; ZA_GENERATED_HEADER="app/builder/$--deviceName--$/$--deviceName--$.h"; __SOURCEFILE__="$FILE_FNAME$"
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros; --separate_cluster_for_initialized_variables
  ICCARM.CCIncludePath2: $FILE_DIR$; $PROJ_DIR$; $--stackDirFromProjBs--$; $--frameworkDirFromProjBs--$; $--frameworkDirFromProjBs--$\..\..; $--frameworkDirFromProjBs--$\..\..\stack; $--frameworkDirFromProjBs--$\..\util; $--frameworkDirFromProjBs--$\include; $--halDirFromProjBs--$; $--halDirFromProjBs--$\plugin; $--halDirFromProjBs--$\..; $--halDirFromProjBs--$\micro\cortexm3\efm32; $--halDirFromProjBs--$\micro\cortexm3\efm32\config; $--halDirFromProjBs--$\micro\cortexm3\efm32\efr32; $--halDirFromProjBs--$\..\..\$--cmsisDir--$\Include; $--halDirFromProjBs--$\..\..\$--deviceDir--$\SiliconLabs\$--chipFamily--$\Include; $--halDirFromProjBs--$\..\..\$--emdrvDir--$\common\inc; $--halDirFromProjBs--$\..\..\$--emdrvDir--$\config; $--halDirFromProjBs--$\..\..\$--emdrvDir--$\dmadrv\inc; $--halDirFromProjBs--$\..\..\$--emdrvDir--$\gpiointerrupt\inc; $--halDirFromProjBs--$\..\..\$--emdrvDir--$\rtcdrv\inc; $--halDirFromProjBs--$\..\..\$--emdrvDir--$\sleep\inc; $--halDirFromProjBs--$\..\..\$--emdrvDir--$\spidrv\inc; $--halDirFromProjBs--$\..\..\$--emdrvDir--$\tempdrv\inc; $--halDirFromProjBs--$\..\..\$--emdrvDir--$\uartdrv\inc; $--halDirFromProjBs--$\..\..\$--emdrvDir--$\ustimer\inc; $--halDirFromProjBs--$\..\..\$--emlibDir--$\inc; $--halDirFromProjBs--$\..\..\middleware\$--glibDir--$; $--halDirFromProjBs--$\..\..\middleware\$--glibDir--$\glib; $--halDirFromProjBs--$\..\..\radio\$--railLibDir--$\plugin; $--halDirFromProjBs--$\..\..\radio\$--railLibDir--$\chip\efr32\rf\common\cortex; $--halDirFromProjBs--$\..\..\radio\$--railLibDir--$\chip\efr32\rf\rfprotocol\ieee802154\cortex; $--stackDirFromProjBs--$\platform\halconfig\inc\hal-config; $--stackDirFromProjBs--$\hardware\module\config; $--stackDirFromProjBs--$\hardware\kit\common\halconfig; $--stackDirFromProjBs--$\hardware\kit\common\bsp
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: $--bootloader--$; CORTEXM3; CORTEXM3_EFM32_MICRO; CORTEXM3_EFR32_MICRO; CORTEXM3_EFR32; EFR32_SERIES$--partHardware.series--$_CONFIG$--partHardware.device_configuration--$_MICRO; $--chipFamily;U--$; $--partNumber;U--$; ATTRIBUTE_STORAGE_CONFIGURATION="app/builder/$--deviceName--$/$--deviceName--$_endpoint_config.h"; CONFIGURATION_HEADER="app/framework/util/config.h"; GENERATED_TOKEN_HEADER="app/builder/$--deviceName--$/$--tokenHeader--$"; PLATFORM_HEADER="$--halDirFromStackFs--$/micro/cortexm3/compiler/iar.h"; ZA_GENERATED_HEADER="app/builder/$--deviceName--$/$--deviceName--$.h"
  AARM.AUserIncludes: $FILE_DIR$; $PROJ_DIR$; $--stackDirFromProjBs--$; $--frameworkDirFromProjBs--$; $--frameworkDirFromProjBs--$\..\..; $--frameworkDirFromProjBs--$\..\..\stack; $--frameworkDirFromProjBs--$\..\util; $--frameworkDirFromProjBs--$\include; $--halDirFromProjBs--$; $--halDirFromProjBs--$\plugin; $--halDirFromProjBs--$\..; $--halDirFromProjBs--$\micro\cortexm3\efm32; $--halDirFromProjBs--$\micro\cortexm3\efm32\config; $--halDirFromProjBs--$\micro\cortexm3\efm32\efr32; $--halDirFromProjBs--$\..\..\$--cmsisDir--$\Include; $--halDirFromProjBs--$\..\..\$--deviceDir--$\SiliconLabs\$--chipFamily--$\Include; $--halDirFromProjBs--$\..\..\$--emdrvDir--$\common\inc; $--halDirFromProjBs--$\..\..\$--emdrvDir--$\config; $--halDirFromProjBs--$\..\..\$--emdrvDir--$\dmadrv\inc; $--halDirFromProjBs--$\..\..\$--emdrvDir--$\gpiointerrupt\inc; $--halDirFromProjBs--$\..\..\$--emdrvDir--$\rtcdrv\inc; $--halDirFromProjBs--$\..\..\$--emdrvDir--$\rtcdrv\test; $--halDirFromProjBs--$\..\..\$--emdrvDir--$\sleep\inc; $--halDirFromProjBs--$\..\..\$--emdrvDir--$\spidrv\inc; $--halDirFromProjBs--$\..\..\$--emdrvDir--$\tempdrv\inc; $--halDirFromProjBs--$\..\..\$--emdrvDir--$\uartdrv\inc; $--halDirFromProjBs--$\..\..\$--emdrvDir--$\ustimer\inc; $--halDirFromProjBs--$\..\..\$--emlibDir--$\inc; $--halDirFromProjBs--$\..\..\middleware\$--glibDir--$; $--halDirFromProjBs--$\..\..\middleware\$--glibDir--$\glib; $--halDirFromProjBs--$\..\..\radio\$--railLibDir--$\chip\efr32\rf\common\cortex; $--halDirFromProjBs--$\..\..\radio\$--railLibDir--$\chip\efr32\rf\rfprotocol\ieee802154\cortex; $--stackDirFromProjBs--$\platform\halconfig\inc\hal-config; $--stackDirFromProjBs--$\hardware\kit\common\halconfig; $--stackDirFromProjBs--$\hardware\kit\common\bsp
  OBJCOPY.OOCOutputFile: $--deviceName--$.s37
  prebuild: $--deviceName--$-prebuild.bat '$TARGET_BPATH$' '$PROJ_DIR$' '$TOOLKIT_DIR$' '$--studioInstallationPath--$'
  postbuild: $--deviceName--$-postbuild.bat '$TARGET_BPATH$' '$PROJ_DIR$' '$TOOLKIT_DIR$' '$--studioInstallationPath--$'
  ILINK.IlinkOutputFile: $--deviceName--$.out
  ILINK.IlinkConfigDefines: FLASH_SIZE=$--flashSize--$; RAM_SIZE=$--ramSize--$; SIMEEPROM_SIZE=$--simeepromSize--$; LOCKBITS_IN_MAINFLASH_SIZE=$--lockbitsInMainflashSize--$; $--bootloader--$=1; EMBER_MALLOC_HEAP_SIZE=$--mallocHeapSize--$
  ILINK.IlinkIcfFile: $--halDirFromProjBs--$\micro\cortexm3\efm32\iar-cfg.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: afv2-bookkeeping.c call-command-handler.c callback-stub.c stack-handler-stub.c cli.c
    $--frameworkDirFromProjFs--$/util/: af-event.c af-main-common.c af-main-soc.c attribute-size.c attribute-storage.c attribute-table.c client-api.c print.c print-formatter.c process-cluster-message.c process-global-message.c service-discovery-common.c service-discovery-soc.c message.c multi-network.c time-util.c util.c
    $--frameworkDirFromProjFs--$/security/: af-node.c af-security-common.c af-trust-center.c crypto-state.c
    $--halDirFromProjFs--$/micro/cortexm3/efm32/: assert-crash-handlers.c button.c cstartup-common.c diagnostic.c faults-v7m.s79 isr-stubs.s79 led.c mfg-token.c micro-common.c micro.c mpu.c sleep-efm32.c token.c ext-device.c
    $--halDirFromProjFs--$/plugin/buzzer/: buzzer-efr32.c
    $--frameworkDirFromProjFs--$/../util/serial/: command-interpreter2.c
    $--halDirFromProjFs--$/micro/generic/: crc.c endian.c mem-util.c random.c token-def.c
    $--frameworkDirFromProjFs--$/../../stack/config/: ember-configuration.c
    $--frameworkDirFromProjFs--$/../util/common/: library.c
    $--frameworkDirFromProjFs--$/cli/: core-cli.c network-cli.c option-cli.c plugin-cli.c security-cli.c zcl-cli.c zdo-cli.c
    $--frameworkDirFromProjFs--$/../util/security/: security-address-cache.c
    $--halDirFromProjFs--$/: ember-base-configuration.c
    $--frameworkDirFromProjFs--$/../util/zigbee-framework/: zigbee-device-common.c zigbee-device-library.c
  group emdrv
    $--halDirFromProjBs--$/../../$--emdrvDir--$/dmadrv/src/: dmadrv.c
    $--halDirFromProjBs--$/../../$--emdrvDir--$/gpiointerrupt/src/: gpiointerrupt.c
    $--halDirFromProjBs--$/../../$--emdrvDir--$/rtcdrv/src/: rtcdriver.c
    $--halDirFromProjBs--$/../../$--emdrvDir--$/sleep/src/: sleep.c
    $--halDirFromProjBs--$/../../$--emdrvDir--$/tempdrv/src/: tempdrv.c
    $--halDirFromProjBs--$/../../$--emdrvDir--$/ustimer/src/: ustimer.c
  group emlib
    $--halDirFromProjBs--$/../../$--emlibDir--$/src/: em_adc.c em_cmu.c em_core.c em_cryotimer.c em_emu.c em_gpio.c em_i2c.c em_ldma.c em_leuart.c em_msc.c em_prs.c em_rmu.c em_rtcc.c em_se.c em_system.c em_timer.c em_usart.c em_wdog.c
    $--halDirFromProjBs--$/../../$--deviceDir--$/SiliconLabs/$--chipFamily;U--$/Source/: system_$--chipFamily;L--$.c
